  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1062()
{
  TestDescription("0x3:Position3 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1062");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:3&ServiceExecuteFeedbackFlag:2//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1063()
{
  TestDescription("0x4:Position4 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1063");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:4&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:4&ServiceExecuteFeedbackFlag:2//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1064()
{
  TestDescription("0x5:Position5 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1064");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:5&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:5&ServiceExecuteFeedbackFlag:2//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1065()
{
  TestDescription("0x6:Position6 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1065");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:6&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:6&ServiceExecuteFeedbackFlag:2//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1066()
{
  TestDescription("0x7:Position7 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1066");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:7&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:7&ServiceExecuteFeedbackFlag:2//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1067()
{
  TestDescription("0xD:Open 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1067");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xD&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xD&ServiceExecuteFeedbackFlag:2//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1068()
{
  TestDescription("0xE:OFF 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1068");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xE&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xE&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1069()
{
  TestDescription("0xF:Error 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1069");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xF&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xF&ServiceExecuteFeedbackFlag:2//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1070()
{
  TestDescription("0x1:Position1 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1070");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:1&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1071()
{
  TestDescription("0x0:Nocommand 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1071");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1072()
{
  TestDescription("0x2:Position2 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1072");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1073()
{
  TestDescription("0x3:Position3 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1073");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:3&ServiceExecuteFeedbackFlag:2//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1074()
{
  TestDescription("0x4:Position4 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1074");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:4&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:4&ServiceExecuteFeedbackFlag:2//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1075()
{
  TestDescription("0x5:Position5 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1075");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:5&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:5&ServiceExecuteFeedbackFlag:2//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1076()
{
  TestDescription("0x6:Position6 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1076");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:6&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:6&ServiceExecuteFeedbackFlag:2//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1077()
{
  TestDescription("0x7:Position7 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1077");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:7&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:7&ServiceExecuteFeedbackFlag:2//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1078()
{
  TestDescription("0xD:Open 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1078");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xD&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xD&ServiceExecuteFeedbackFlag:2//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1079()
{
  TestDescription("0xE:OFF 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1079");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xE&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xE&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1080()
{
  TestDescription("0xF:Error 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1080");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xF&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xF&ServiceExecuteFeedbackFlag:2//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_zuo_1081()
{
  TestDescription("0x1:Position1 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-左)-1081");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:1&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_zuo_1082()
{
  TestDescription("0x2:Position2 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-左)-1082");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_zuo_1083()
{
  TestDescription("0x3:Position3 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-左)-1083");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 3&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 3&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_zuo_1084()
{
  TestDescription("0x4:Position4 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-左)-1084");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 4&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 4&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:4&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:4&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 4&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 4&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_zuo_1085()
{
  TestDescription("0x5:Position5 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-左)-1085");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 5&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:5&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:5&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 5&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_zuo_1086()
{
  TestDescription("0x6:Position6 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-左)-1086");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 6&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 6&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:6&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:6&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 6&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 6&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_zuo_1087()
{
  TestDescription("0x7:Position7 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-左)-1087");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 7&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 7&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:7&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:7&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 7&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 7&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_zuo_1088()
{
  TestDescription("0x0:Nocommand 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-左)-1088");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 0&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 0&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:0&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:0&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 0&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 0&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_zuo_1089()
{
  TestDescription("0xD:Open 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-左)-1089");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 0xD&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 0xD&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:0xD&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:0xD&ServiceExecuteFeedbackFlag:2//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 0xD&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 0xD&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_zuo_1090()
{
  TestDescription("0xE:OFF 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-左)-1090");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 0xE&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 0xE&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:0xE&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:0xE&ServiceExecuteFeedbackFlag:2//off
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 0xE&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 0xE&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_zuo_1091()
{
  TestDescription("0xF:Error 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-左)-1091");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 0xF&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 0xF&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:0xF&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLHorzPosStruct.Veh_SetEAVRLHorzPos:0xF&ServiceExecuteFeedbackFlag:2//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLHorzPosRespStruct.Veh_SetEAVRLHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLHorzPosStruct.SetEAVRLHorzPos 0xF&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLHorzPosStruct.SetEAVRLHorzPos 0xF&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_zuo_1092()
{
  TestDescription("0x0:Nocommand 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-左)-1092");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLVertPosStruct.SetEAVRLVertPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:0&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:0&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLVertPosStruct.SetEAVRLVertPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_zuo_1093()
{
  TestDescription("0x1:Position1 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-左)-1093");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLVertPosStruct.SetEAVRLVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:1&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLVertPosStruct.SetEAVRLVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_zuo_1094()
{
  TestDescription("0x2:Position2 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-左)-1094");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLVertPosStruct.SetEAVRLVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLVertPosStruct.SetEAVRLVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_zuo_1095()
{
  TestDescription("0x3:Position3 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-左)-1095");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLVertPosStruct.SetEAVRLVertPos 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 3&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLVertPosStruct.SetEAVRLVertPos 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 3&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_zuo_1096()
{
  TestDescription("0x4:Position4 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-左)-1096");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLVertPosStruct.SetEAVRLVertPos 4&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 4&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:4&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:4&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLVertPosStruct.SetEAVRLVertPos 4&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 4&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_zuo_1097()
{
  TestDescription("0x5:Position5 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-左)-1097");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLVertPosStruct.SetEAVRLVertPos 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 5&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:5&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:5&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLVertPosStruct.SetEAVRLVertPos 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 5&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_zuo_1098()
{
  TestDescription("0x6:Position6 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-左)-1098");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLVertPosStruct.SetEAVRLVertPos 6&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 6&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:6&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:6&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLVertPosStruct.SetEAVRLVertPos 6&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 6&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_zuo_1099()
{
  TestDescription("0x7:Position7 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-左)-1099");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLVertPosStruct.SetEAVRLVertPos 7&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 7&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:7&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:7&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLVertPosStruct.SetEAVRLVertPos 7&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 7&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_zuo_1100()
{
  TestDescription("0xD:Open 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-左)-1100");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLVertPosStruct.SetEAVRLVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 0xD
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:0xD&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:0xD&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLVertPosStruct.SetEAVRLVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 0xD
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_zuo_1101()
{
  TestDescription("0xE:OFF 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-左)-1101");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLVertPosStruct.SetEAVRLVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 0xE
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:0xE&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:0xE&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLVertPosStruct.SetEAVRLVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 0xE
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_zuo_1102()
{
  TestDescription("0xF:Error 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-左)-1102");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLVertPosStruct.SetEAVRLVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 0xF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:0xF&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLVertPosStruct.Veh_SetEAVRLVertPos:0xF&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLVertPosRespStruct.Veh_SetEAVRLVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLVertPosStruct.SetEAVRLVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLVertPosStruct.SetEAVRLVertPos 0xF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_you_1103()
{
  TestDescription("0x0:Nocommand 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-右)-1103");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:0&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:0&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_you_1104()
{
  TestDescription("0x1:Position1 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-右)-1104");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:1&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_you_1105()
{
  TestDescription("0x2:Position2 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-右)-1105");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_you_1106()
{
  TestDescription("0x3:Position3 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-右)-1106");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 3&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 3&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_you_1107()
{
  TestDescription("0x4:Position4 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-右)-1107");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 4&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 4&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:4&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:4&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 4&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 4&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_you_1108()
{
  TestDescription("0x5:Position5 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-右)-1108");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 5&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:5&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:5&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 5&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_you_1109()
{
  TestDescription("0x6:Position6 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-右)-1109");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 6&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 6&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:6&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:6&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 6&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 6&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_you_1110()
{
  TestDescription("0x7:Position7 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-右)-1110");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 7&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 7&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:7&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:7&ServiceExecuteFeedbackFlag:2//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 7&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 7&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_you_1111()
{
  TestDescription("0xD:Open 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-右)-1111");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 0xD&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 0xD&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:0xD&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:0xD&ServiceExecuteFeedbackFlag:2//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 0xD&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 0xD&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_you_1112()
{
  TestDescription("0xE:OFF 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-右)-1112");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 0xE&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 0xE&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:0xE&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:0xE&ServiceExecuteFeedbackFlag:2//off
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 0xE&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 0xE&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoushuipingweizhidiaojiehoupai_you_1113()
{
  TestDescription("0xF:Error 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口水平位置调节(后排-右)-1113");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 0xF&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 0xF&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:0xF&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRHorzPosStruct.Veh_SetEAVRRHorzPos:0xF&ServiceExecuteFeedbackFlag:2//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRHorzPosRespStruct.Veh_SetEAVRRHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRHorzPosStruct.SetEAVRRHorzPos 0xF&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRHorzPosStruct.SetEAVRRHorzPos 0xF&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_you_1114()
{
  TestDescription("0x0:Nocommand 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-右)-1114");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRVertPosStruct.SetEAVRRVertPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:0&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:0&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRVertPosStruct.SetEAVRRVertPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_you_1115()
{
  TestDescription("0x1:Position1 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-右)-1115");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRVertPosStruct.SetEAVRRVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:1&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRVertPosStruct.SetEAVRRVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_you_1116()
{
  TestDescription("0x2:Position2 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-右)-1116");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRVertPosStruct.SetEAVRRVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRVertPosStruct.SetEAVRRVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_you_1117()
{
  TestDescription("0x3:Position3 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-右)-1117");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRVertPosStruct.SetEAVRRVertPos 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 3&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRVertPosStruct.SetEAVRRVertPos 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 3&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_you_1118()
{
  TestDescription("0x4:Position4 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-右)-1118");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRVertPosStruct.SetEAVRRVertPos 4&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 4&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:4&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:4&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRVertPosStruct.SetEAVRRVertPos 4&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 4&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_you_1119()
{
  TestDescription("0x5:Position5 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-右)-1119");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRVertPosStruct.SetEAVRRVertPos 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 5&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:5&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:5&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRVertPosStruct.SetEAVRRVertPos 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 5&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_you_1120()
{
  TestDescription("0x6:Position6 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-右)-1120");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRVertPosStruct.SetEAVRRVertPos 6&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 6&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:6&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:6&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRVertPosStruct.SetEAVRRVertPos 6&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 6&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_you_1121()
{
  TestDescription("0x7:Position7 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-右)-1121");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRVertPosStruct.SetEAVRRVertPos 7&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 7&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:7&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:7&ServiceExecuteFeedbackFlag:2//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRVertPosStruct.SetEAVRRVertPos 7&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 7&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_you_1122()
{
  TestDescription("0xD:Open 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-右)-1122");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRVertPosStruct.SetEAVRRVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 0xD
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:0xD&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:0xD&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRVertPosStruct.SetEAVRRVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 0xD
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_you_1123()
{
  TestDescription("0xE:OFF 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-右)-1123");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRVertPosStruct.SetEAVRRVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 0xE
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:0xE&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:0xE&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRVertPosStruct.SetEAVRRVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 0xE
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkouchuizhiweizhidiaojiehoupai_you_1124()
{
  TestDescription("0xF:Error 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口垂直位置调节(后排-右)-1124");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRVertPosStruct.SetEAVRRVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 0xF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:0xF&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRVertPosStruct.Veh_SetEAVRRVertPos:0xF&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRVertPosRespStruct.Veh_SetEAVRRVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRVertPosStruct.SetEAVRRVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRVertPosStruct.SetEAVRRVertPos 0xF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qianhoukongdiaozidongmoshi_1125()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-前后空调自动模式-1125");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qianhoukongdiaozidongmoshi_1126()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-前后空调自动模式-1126");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qianhoukongdiaozidongmoshi_1127()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-前后空调自动模式-1127");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnFrACStruct.TurnOnFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnFrACStruct.TurnOnFrAC 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnFrACStruct.TurnOnFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnFrACStruct.TurnOnFrAC 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_zhujiadiandongchufengkoumoshidiaojie_1128()
{
  TestDescription("0x1:Singlewind 远控域 Power=off");
  teststep("warning","原始用例id为SYS-CDCU-主驾电动出风口模式调节-1128");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 1&MemoryReq 0 //Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 1&MemoryReq 0 //Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhujiadiandongchufengkoumoshidiaojie_1129()
{
  TestDescription("0x2:Mirrorwind 远控域 Power=off");
  teststep("warning","原始用例id为SYS-CDCU-主驾电动出风口模式调节-1129");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 2&MemoryReq 1 //Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 2&MemoryReq 1 //Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhujiadiandongchufengkoumoshidiaojie_1130()
{
  TestDescription("0x3:Freewind 远控域 Power=off");
  teststep("warning","原始用例id为SYS-CDCU-主驾电动出风口模式调节-1130");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 3 //Freewind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Freewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 3 //Freewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhujiadiandongchufengkoumoshidiaojie_1131()
{
  TestDescription("0x4:Avoid 远控域 Power=off");
  teststep("warning","原始用例id为SYS-CDCU-主驾电动出风口模式调节-1131");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 4 //Avoid
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Avoid
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 4 //Avoid
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhujiadiandongchufengkoumoshidiaojie_1132()
{
  TestDescription("0x5:Intelligent 远控域 Power=off");
  teststep("warning","原始用例id为SYS-CDCU-主驾电动出风口模式调节-1132");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 5 //Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 5 //Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_fujiadiandongchufengkoumoshidiaojie_1133()
{
  TestDescription("0x1:Singlewind Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-副驾电动出风口模式调节-1133");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 1&MemoryReq 0 //Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 1&MemoryReq 0 //Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_fujiadiandongchufengkoumoshidiaojie_1134()
{
  TestDescription("0x2:Mirrorwind Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-副驾电动出风口模式调节-1134");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 2&MemoryReq 1 //Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 2&MemoryReq 1 //Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_fujiadiandongchufengkoumoshidiaojie_1135()
{
  TestDescription("0x3:Freewind Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-副驾电动出风口模式调节-1135");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 3 //Freewind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Freewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 3 //Freewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_fujiadiandongchufengkoumoshidiaojie_1136()
{
  TestDescription("0x4:Avoid Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-副驾电动出风口模式调节-1136");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 4 //Avoid
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Avoid
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 4 //Avoid
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_fujiadiandongchufengkoumoshidiaojie_1137()
{
  TestDescription("0x5:Intelligent Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-副驾电动出风口模式调节-1137");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 5 //Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 5 //Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojie_1138()
{
  TestDescription("IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节-1138");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_NM.I_LDCU_NMReq_CDCU 1"); // 测试步骤 TC_CANTest SET I_LDCU_NM.I_LDCU_NMReq_CDCU 1 //网络唤醒维持帧
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojie_1139()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节-1139");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVSweepWindStruct.SetEAVSweepWind 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 1&MemoryReq 0 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVSweepWindStruct.SetEAVSweepWind 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 1&MemoryReq 0 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojie_1140()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节-1140");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVSweepWindStruct.SetEAVSweepWind 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 1&MemoryReq 1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVSweepWindStruct.SetEAVSweepWind 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 1&MemoryReq 1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojie_1141()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节-1141");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVSweepWindStruct.SetEAVSweepWind 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 2&MemoryReq 0 //ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVSweepWindStruct.SetEAVSweepWind 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 2&MemoryReq 0 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojie_1142()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节-1142");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVSweepWindStruct.SetEAVSweepWind 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 2&MemoryReq 1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVSweepWindStruct.SetEAVSweepWind 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 2&MemoryReq 1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojiehoupai_1143()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节(后排)-1143");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 0 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 0 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojiehoupai_1144()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节(后排)-1144");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojiehoupai_1145()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节(后排)-1145");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 0 //ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 0 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojiehoupai_1146()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节(后排)-1146");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1147()
{
  TestDescription("0x1:Position1 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1147");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1148()
{
  TestDescription("0x2:Position2 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1148");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1149()
{
  TestDescription("0x3:Position3 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1149");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1150()
{
  TestDescription("0x4:Position4 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1150");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1151()
{
  TestDescription("0x5:Position5 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1151");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1152()
{
  TestDescription("0x6:Position6 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1152");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1153()
{
  TestDescription("0x7:Position7 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1153");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1154()
{
  TestDescription("0xD:Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1154");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1155()
{
  TestDescription("0xE:OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1155");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1156()
{
  TestDescription("0xF:Error Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1156");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1157()
{
  TestDescription("0x1:Position1 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1157");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1158()
{
  TestDescription("0x2:Position2 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1158");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1159()
{
  TestDescription("0x3:Position3 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1159");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1160()
{
  TestDescription("0x4:Position4 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1160");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1161()
{
  TestDescription("0x5:Position5 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1161");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1162()
{
  TestDescription("0x6:Position6 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1162");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1163()
{
  TestDescription("0x7:Position7 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1163");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1164()
{
  TestDescription("0xD:Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1164");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1165()
{
  TestDescription("0xE:OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1165");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1166()
{
  TestDescription("0xF:Error Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1166");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1167()
{
  TestDescription("0x1:Position1 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1167");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1168()
{
  TestDescription("0x2:Position2 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1168");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1169()
{
  TestDescription("0x3:Position3 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1169");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1170()
{
  TestDescription("0x4:Position4 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1170");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1171()
{
  TestDescription("0x5:Position5 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1171");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1172()
{
  TestDescription("0x6:Position6 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1172");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1173()
{
  TestDescription("0x7:Position7 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1173");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1174()
{
  TestDescription("0xD:Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1174");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1175()
{
  TestDescription("0xE:OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1175");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1176()
{
  TestDescription("0xF:Error Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1176");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1177()
{
  TestDescription("0x1:Position1 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1177");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1178()
{
  TestDescription("0x2:Position2 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1178");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1179()
{
  TestDescription("0x3:Position3 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1179");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1180()
{
  TestDescription("0x4:Position4 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1180");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1181()
{
  TestDescription("0x5:Position5 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1181");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1182()
{
  TestDescription("0x6:Position6 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1182");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1183()
{
  TestDescription("0x7:Position7 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1183");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1184()
{
  TestDescription("0xD:Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1184");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1185()
{
  TestDescription("0xE:OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1185");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1186()
{
  TestDescription("0xF:Error Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1186");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1187()
{
  TestDescription("0x1:Position1 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1187");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1188()
{
  TestDescription("0x2:Position2 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1188");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1189()
{
  TestDescription("0x3:Position3 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1189");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1190()
{
  TestDescription("0x4:Position4 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1190");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1191()
{
  TestDescription("0x5:Position5 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1191");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1192()
{
  TestDescription("0x6:Position6 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1192");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1193()
{
  TestDescription("0x7:Position7 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1193");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1194()
{
  TestDescription("0xD:Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1194");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1195()
{
  TestDescription("0xE:OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1195");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1196()
{
  TestDescription("0xF:Error Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1196");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1197()
{
  TestDescription("0x1:Position1 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1197");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1198()
{
  TestDescription("0x2:Position2 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1198");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1199()
{
  TestDescription("0x3:Position3 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1199");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1200()
{
  TestDescription("0x4:Position4 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1200");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1201()
{
  TestDescription("0x5:Position5 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1201");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1202()
{
  TestDescription("0x6:Position6 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1202");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1203()
{
  TestDescription("0x7:Position7 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1203");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1204()
{
  TestDescription("0xD:Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1204");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1205()
{
  TestDescription("0xE:OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1205");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1206()
{
  TestDescription("0xF:Error Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1206");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1207()
{
  TestDescription("0x1:Position1 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1207");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1208()
{
  TestDescription("0x2:Position2 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1208");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1209()
{
  TestDescription("0x3:Position3 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1209");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1210()
{
  TestDescription("0x4:Position4 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1210");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1211()
{
  TestDescription("0x5:Position5 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1211");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1212()
{
  TestDescription("0x6:Position6 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1212");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1213()
{
  TestDescription("0x7:Position7 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1213");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1214()
{
  TestDescription("0xD:Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1214");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1215()
{
  TestDescription("0xE:OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1215");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1216()
{
  TestDescription("0xF:Error Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1216");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1217()
{
  TestDescription("0x1:Position1 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1217");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1218()
{
  TestDescription("0x2:Position2 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1218");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1219()
{
  TestDescription("0x3:Position3 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1219");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1220()
{
  TestDescription("0x4:Position4 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1220");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1221()
{
  TestDescription("0x5:Position5 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1221");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1222()
{
  TestDescription("0x6:Position6 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1222");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1223()
{
  TestDescription("0x7:Position7 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1223");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1224()
{
  TestDescription("0xD:Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1224");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1225()
{
  TestDescription("0xE:OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1225");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1226()
{
  TestDescription("0xF:Error Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1226");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qianhoukongdiaozidongmoshi_1227()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-前后空调自动模式-1227");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qianhoukongdiaozidongmoshi_1228()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-前后空调自动模式-1228");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qianhoukongdiaozidongmoshi_1229()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-前后空调自动模式-1229");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnFrACStruct.TurnOnFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnFrACStruct.TurnOnFrAC 1 //MemoAC
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnFrACStruct.TurnOnFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnFrACStruct.TurnOnFrAC 1 //MemoAC
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_zhujiadiandongchufengkoumoshidiaojie_1230()
{
  TestDescription("0x1:Singlewind Power=OFF 远控域");
  teststep("warning","原始用例id为SYS-CDCU-主驾电动出风口模式调节-1230");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 1 //Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 1 //Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhujiadiandongchufengkoumoshidiaojie_1231()
{
  TestDescription("0x2:Mirrorwind Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-主驾电动出风口模式调节-1231");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 2 //Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 2 //Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhujiadiandongchufengkoumoshidiaojie_1232()
{
  TestDescription("0x3:Freewind Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-主驾电动出风口模式调节-1232");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 3 //Freewind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Freewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 3 //Freewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhujiadiandongchufengkoumoshidiaojie_1233()
{
  TestDescription("0x4:Avoid Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-主驾电动出风口模式调节-1233");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 4 //Avoid
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Avoid
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 4 //Avoid
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhujiadiandongchufengkoumoshidiaojie_1234()
{
  TestDescription("0x5:Intelligent Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-主驾电动出风口模式调节-1234");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 5 //Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 5 //Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_fujiadiandongchufengkoumoshidiaojie_1235()
{
  TestDescription("0x1:Singlewind Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-副驾电动出风口模式调节-1235");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 1 //Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 1 //Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_fujiadiandongchufengkoumoshidiaojie_1236()
{
  TestDescription("0x2:Mirrorwind Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-副驾电动出风口模式调节-1236");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 2 //Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 2 //Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_fujiadiandongchufengkoumoshidiaojie_1237()
{
  TestDescription("0x3:Freewind Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-副驾电动出风口模式调节-1237");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 3 //Freewind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Freewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 3 //Freewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_fujiadiandongchufengkoumoshidiaojie_1238()
{
  TestDescription("0x4:Avoid Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-副驾电动出风口模式调节-1238");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 4 //Avoid
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Avoid
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 4 //Avoid
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_fujiadiandongchufengkoumoshidiaojie_1239()
{
  TestDescription("0x5:Intelligent Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-副驾电动出风口模式调节-1239");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 5 //Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 5 //Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojie_1240()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节-1240");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVSweepWindStruct.SetEAVSweepWind 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVSweepWindStruct.SetEAVSweepWind 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojie_1241()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节-1241");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVSweepWindStruct.SetEAVSweepWind 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 2 //ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVSweepWindStruct.SetEAVSweepWind 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 2 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojiehoupai_1242()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节(后排)-1242");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetREAVSweepWindStruct.SetREAVSweepWind 1"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetREAVSweepWindStruct.SetREAVSweepWind 1"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojiehoupai_1243()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节(后排)-1243");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetREAVSweepWindStruct.SetREAVSweepWind 2"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 2 //ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetREAVSweepWindStruct.SetREAVSweepWind 2"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 2 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1244()
{
  TestDescription("0x1:Position1 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1244");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1245()
{
  TestDescription("0x2:Position2 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1245");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 2 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 2 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1246()
{
  TestDescription("0x3:Position3 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1246");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1247()
{
  TestDescription("0x4:Position4 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1247");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1248()
{
  TestDescription("0x5:Position5 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1248");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1249()
{
  TestDescription("0x6:Position6 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1249");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1250()
{
  TestDescription("0x7:Position7 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1250");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1251()
{
  TestDescription("0xD:Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1251");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1252()
{
  TestDescription("0xE:OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1252");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1253()
{
  TestDescription("0xF:Error Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1253");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1254()
{
  TestDescription("0x1:Position1 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1254");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1255()
{
  TestDescription("0x2:Position2 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1255");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 2 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 2 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1256()
{
  TestDescription("0x3:Position3 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1256");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1257()
{
  TestDescription("0x4:Position4 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1257");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1258()
{
  TestDescription("0x5:Position5 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1258");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1259()
{
  TestDescription("0x6:Position6 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1259");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1260()
{
  TestDescription("0x7:Position7 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1260");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1261()
{
  TestDescription("0xD:Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1261");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1262()
{
  TestDescription("0xE:OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1262");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1263()
{
  TestDescription("0xF:Error Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1263");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1264()
{
  TestDescription("0x1:Position1 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1264");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1265()
{
  TestDescription("0x2:Position2 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1265");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 2 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 2 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1266()
{
  TestDescription("0x3:Position3 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1266");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1267()
{
  TestDescription("0x4:Position4 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1267");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1268()
{
  TestDescription("0x5:Position5 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1268");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1269()
{
  TestDescription("0x6:Position6 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1269");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1270()
{
  TestDescription("0x7:Position7 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1270");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1271()
{
  TestDescription("0xD:Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1271");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1272()
{
  TestDescription("0xE:OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1272");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1273()
{
  TestDescription("0xF:Error Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1273");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1274()
{
  TestDescription("0x1:Position1 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1274");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1275()
{
  TestDescription("0x2:Position2 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1275");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 2 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 2 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1276()
{
  TestDescription("0x3:Position3 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1276");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1277()
{
  TestDescription("0x4:Position4 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1277");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1278()
{
  TestDescription("0x5:Position5 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1278");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1279()
{
  TestDescription("0x6:Position6 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1279");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1280()
{
  TestDescription("0x7:Position7 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1280");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1281()
{
  TestDescription("0xD:Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1281");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1282()
{
  TestDescription("0xE:OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1282");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1283()
{
  TestDescription("0xF:Error Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1283");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1284()
{
  TestDescription("0x1:Position1 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1284");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1285()
{
  TestDescription("0x2:Position2 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1285");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 2 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 2 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1286()
{
  TestDescription("0x3:Position3 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1286");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1287()
{
  TestDescription("0x4:Position4 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1287");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1288()
{
  TestDescription("0x5:Position5 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1288");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1289()
{
  TestDescription("0x6:Position6 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1289");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1290()
{
  TestDescription("0x7:Position7 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1290");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1291()
{
  TestDescription("0xD:Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1291");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1292()
{
  TestDescription("0xE:OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1292");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1293()
{
  TestDescription("0xF:Error Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1293");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1294()
{
  TestDescription("0x1:Position1 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1294");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1295()
{
  TestDescription("0x2:Position2 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1295");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 2 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 2 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1296()
{
  TestDescription("0x3:Position3 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1296");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1297()
{
  TestDescription("0x4:Position4 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1297");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1298()
{
  TestDescription("0x5:Position5 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1298");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1299()
{
  TestDescription("0x6:Position6 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1299");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1300()
{
  TestDescription("0x7:Position7 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1300");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1301()
{
  TestDescription("0xD:Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1301");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1302()
{
  TestDescription("0xE:OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1302");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1303()
{
  TestDescription("0xF:Error Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1303");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1304()
{
  TestDescription("0x1:Position1 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1304");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1305()
{
  TestDescription("0x2:Position2 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1305");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 2 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 2 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1306()
{
  TestDescription("0x3:Position3 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1306");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1307()
{
  TestDescription("0x4:Position4 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1307");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1308()
{
  TestDescription("0x5:Position5 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1308");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1309()
{
  TestDescription("0x6:Position6 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1309");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1310()
{
  TestDescription("0x7:Position7 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1310");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1311()
{
  TestDescription("0xD:Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1311");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1312()
{
  TestDescription("0xE:OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1312");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1313()
{
  TestDescription("0xF:Error Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1313");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1314()
{
  TestDescription("0x1:Position1 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1314");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1315()
{
  TestDescription("0x2:Position2 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1315");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 2 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 2"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 2 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1316()
{
  TestDescription("0x3:Position3 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1316");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1317()
{
  TestDescription("0x4:Position4 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1317");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1318()
{
  TestDescription("0x5:Position5 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1318");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1319()
{
  TestDescription("0x6:Position6 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1319");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1320()
{
  TestDescription("0x7:Position7 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1320");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1321()
{
  TestDescription("0xD:Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1321");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xD&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1322()
{
  TestDescription("0xE:OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1322");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
