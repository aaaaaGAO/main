  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 7"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 7
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0402()
{
  TestDescription("LDCU_ChrgConnSt_Disp=DC Charge connector  connected Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0402");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0403()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0403");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0404()
{
  TestDescription("LDCU_dstBatDisp 信号丢失 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0404");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("1"); // 测试步骤 TC_Sleep 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 2//HVAC_HIGH_TEMP_STOP_LOW_SOC
  g_CAN_Bus_Swc_Disable("I_LDCU_SysStDisp1"); // 测试步骤 TC_CANTest Disable I_LDCU_SysStDisp1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 2//HVAC_HIGH_TEMP_STOP_LOW_SOC
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0405()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0405");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0406()
{
  TestDescription("LDCU_DriverDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0406");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0407()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0407");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0408()
{
  TestDescription("LDCU_FLWinPosStFB ＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0408");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0409()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0409");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0410()
{
  TestDescription("LDCU_RLDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0410");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0411()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0411");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0412()
{
  TestDescription("RDCU_FRWinPosStFB ＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0412");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0413()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0413");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0414()
{
  TestDescription("RDCU_PsngrDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0414");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0415()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0415");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0416()
{
  TestDescription("RDCU_RRWinPosStFB＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0416");
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0417()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0417");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0418()
{
  TestDescription("RDCU_RRDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0418");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0419()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0419");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0420()
{
  TestDescription("LDCU_RLWinPosStFB ＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0420");
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0421()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0421");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0422()
{
  TestDescription("RDCU_PLGSts！=Closed Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0422");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 3"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0423()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0423");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0425()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0425");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0426()
{
  TestDescription("RDCU_PLGSts！=Closed Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0426");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 4"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0427()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0427");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0428()
{
  TestDescription("ACSysState Eventgroup 信息 ACPowerSt==OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0428");
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 4 traceback2//HVAC_HIGH_TEMP_STOP_AC_ERROR
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt 0 sleep0"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt 0 sleep0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 4 traceback2//HVAC_HIGH_TEMP_STOP_AC_ERROR
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0429()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0429");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0430()
{
  TestDescription("RDCU_PLGSts！=Closed Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0430");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 2"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0431()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0431");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0432()
{
  TestDescription("LDCU_EVSysReadySt==Not ready Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0432");
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 8"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 8//HVAC_HIGH_TEMP_STOP_IGOFF
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 0"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 8"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 8//HVAC_HIGH_TEMP_STOP_IGOFF
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("1"); // 测试步骤 TC_Sleep 1
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0433()
{
  TestDescription("空调自清洁远控功能运行中 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0433");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0434()
{
  TestDescription("LDCU_dstBatDisp ≤ 80KM Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0434");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 80"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 80
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0435()
{
  TestDescription("空调自清洁远控功能运行中 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0435");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0436()
{
  TestDescription("LDCU_ChrgConnSt_Disp=AC Charge connector connected Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0436");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0437()
{
  TestDescription("空调自清洁远控功能运行中 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0437");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0438()
{
  TestDescription("LDCU_dstBatDisp 信 号 丢 失 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0438");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("1"); // 测试步骤 TC_Sleep 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  g_CAN_Bus_Swc_Disable("I_LDCU_SysStDisp1"); // 测试步骤 TC_CANTest Disable I_LDCU_SysStDisp1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0439()
{
  TestDescription("空调自清洁远控功能运行中 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0439");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0440()
{
  TestDescription("LDCU_ChrgConnSt_Disp=DC Charge connector connected Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0440");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0441()
{
  TestDescription("空调自清洁远控功能运行中 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0441");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0442()
{
  TestDescription("LDCU_DriverDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0442");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0443()
{
  TestDescription("空调自清洁远控功能运行中 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0443");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0444()
{
  TestDescription("LDCU_FLWinPosStFB ＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0444");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0445()
{
  TestDescription("空调自清洁远控功能运行中 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0445");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0446()
{
  TestDescription("LDCU_RLDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0446");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0447()
{
  TestDescription("空调自清洁远控功能运行中 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0447");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0448()
{
  TestDescription("RDCU_FRWinPosStFB ＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0448");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0449()
{
  TestDescription("空调自清洁远控功能运行中 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0449");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0450()
{
  TestDescription("RDCU_PsngrDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0450");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0451()
{
  TestDescription("空调自清洁远控功能运行中 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0451");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0452()
{
  TestDescription("RDCU_RRWinPosStFB＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0452");
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0453()
{
  TestDescription("空调自清洁远控功能运行中 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0453");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0454()
{
  TestDescription("RDCU_RRDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0454");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0455()
{
  TestDescription("空调自清洁远控功能运行中 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0455");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0456()
{
  TestDescription("LDCU_RLWinPosStFB ＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0456");
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0457()
{
  TestDescription("空调自清洁远控功能运行中 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0457");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0458()
{
  TestDescription("RDCU_PLGSts！=Closed Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0458");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 3"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0459()
{
  TestDescription("空调自清洁远控功能运行中 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0459");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0460()
{
  TestDescription("空调自清洁远控功能运行中 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0460");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0461()
{
  TestDescription("RDCU_PLGSts！=Closed Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0461");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 4"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0462()
{
  TestDescription("空调自清洁远控功能运行中 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0462");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0463()
{
  TestDescription("空调自清洁远控功能运行中 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0463");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0464()
{
  TestDescription("RDCU_PLGSts！=Closed Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0464");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 2"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0465()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0465");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0466()
{
  TestDescription("LDCU_dstBatDisp ≤ 80KM Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0466");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 80"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 80
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0467()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0467");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0468()
{
  TestDescription("LDCU_ChrgConnSt_Disp=AC Charge connector connected Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0468");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0469()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0469");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0470()
{
  TestDescription("LDCU_dstBatDisp 信 号 丢 失 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0470");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("1"); // 测试步骤 TC_Sleep 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  g_CAN_Bus_Swc_Disable("I_LDCU_SysStDisp1"); // 测试步骤 TC_CANTest Disable I_LDCU_SysStDisp1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0471()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0471");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0472()
{
  TestDescription("LDCU_ChrgConnSt_Disp=DC Charge connector connected Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0472");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0473()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0473");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0474()
{
  TestDescription("LDCU_DriverDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0474");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0475()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0475");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0476()
{
  TestDescription("LDCU_FLWinPosStFB ＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0476");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0477()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0477");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0478()
{
  TestDescription("LDCU_RLDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0478");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0479()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0479");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0480()
{
  TestDescription("RDCU_FRWinPosStFB ＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0480");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0481()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0481");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0482()
{
  TestDescription("RDCU_PsngrDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0482");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0483()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0483");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0484()
{
  TestDescription("RDCU_FRWinPosStFB ＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0484");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0485()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0485");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0486()
{
  TestDescription("RDCU_RRDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0486");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0487()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0487");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0488()
{
  TestDescription("RDCU_RRWinPosStFB＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0488");
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0489()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0489");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0490()
{
  TestDescription("RDCU_PLGSts！=Closed Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0490");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 3"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0491()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0491");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0492()
{
  TestDescription("LDCU_RLWinPosStFB ＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0492");
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0493()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0493");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0494()
{
  TestDescription("RDCU_PLGSts！=Closed Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0494");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 4"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0495()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0495");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0496()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0496");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0497()
{
  TestDescription("RDCU_PLGSts！=Closed Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0497");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 2"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0498()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0498");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0499()
{
  TestDescription("LDCU_dstBatDisp ≤ 80KM Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0499");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 80"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 80
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0500()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0500");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0501()
{
  TestDescription("LDCU_ChrgConnSt_Disp=AC Charge connector connected Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0501");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0502()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0502");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0503()
{
  TestDescription("LDCU_dstBatDisp 信 号 丢 失 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0503");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("1"); // 测试步骤 TC_Sleep 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  g_CAN_Bus_Swc_Disable("I_LDCU_SysStDisp1"); // 测试步骤 TC_CANTest Disable I_LDCU_SysStDisp1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0504()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0504");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0505()
{
  TestDescription("LDCU_ChrgConnSt_Disp=DC Charge connector connected Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0505");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0506()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0506");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0507()
{
  TestDescription("LDCU_DriverDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0507");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0508()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0508");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0509()
{
  TestDescription("LDCU_FLWinPosStFB ＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0509");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0510()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0510");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0511()
{
  TestDescription("LDCU_RLDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0511");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0512()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0512");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0513()
{
  TestDescription("RDCU_FRWinPosStFB ＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0513");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0514()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0514");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0515()
{
  TestDescription("RDCU_PsngrDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0515");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0516()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0516");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0517()
{
  TestDescription("RDCU_RRWinPosStFB＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0517");
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0518()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0518");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0519()
{
  TestDescription("RDCU_RRDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0519");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0520()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0520");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0521()
{
  TestDescription("LDCU_RLWinPosStFB ＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0521");
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0522()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0522");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0523()
{
  TestDescription("RDCU_PLGSts！=Closed Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0523");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 3"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0524()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0524");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0525()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0525");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0526()
{
  TestDescription("RDCU_PLGSts！=Closed Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0526");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 4"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0527()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0527");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0528()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0528");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0529()
{
  TestDescription("RDCU_PLGSts！=Closed Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0529");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 2"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0530()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0530");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0531()
{
  TestDescription("LDCU_dstBatDisp ≤ 80KM Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0531");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 80"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 80
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0532()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0532");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0533()
{
  TestDescription("LDCU_ChrgConnSt_Disp=AC Charge connector connected Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0533");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0534()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0534");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0535()
{
  TestDescription("LDCU_dstBatDisp 信 号 丢 失 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0535");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("1"); // 测试步骤 TC_Sleep 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  g_CAN_Bus_Swc_Disable("I_LDCU_SysStDisp1"); // 测试步骤 TC_CANTest Disable I_LDCU_SysStDisp1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0536()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0536");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0537()
{
  TestDescription("LDCU_ChrgConnSt_Disp=DC Charge connector connected Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0537");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0538()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0538");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0539()
{
  TestDescription("LDCU_DriverDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0539");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0540()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0540");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0541()
{
  TestDescription("LDCU_FLWinPosStFB ＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0541");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0542()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0542");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0543()
{
  TestDescription("LDCU_RLDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0543");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0544()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0544");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0545()
{
  TestDescription("RDCU_FRWinPosStFB ＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0545");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0546()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0546");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0547()
{
  TestDescription("RDCU_PsngrDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0547");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0548()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0548");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0549()
{
  TestDescription("RDCU_RRWinPosStFB＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0549");
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0550()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0550");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0551()
{
  TestDescription("RDCU_RRDoorAjarSt==Open Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0551");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0552()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0552");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0553()
{
  TestDescription("LDCU_RLWinPosStFB ＞ 4% Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0553");
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0554()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0554");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0555()
{
  TestDescription("RDCU_PLGSts！=Closed Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0555");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 3"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0556()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0556");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0557()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0557");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0558()
{
  TestDescription("RDCU_PLGSts！=Closed Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0558");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 4"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0559()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0559");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0560()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0560");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0561()
{
  TestDescription("RDCU_PLGSts！=Closed Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0561");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 2"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_wendudiaojie_0562()
{
  TestDescription("主驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0562");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
