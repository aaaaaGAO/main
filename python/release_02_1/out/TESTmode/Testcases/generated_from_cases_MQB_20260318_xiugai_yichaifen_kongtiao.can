  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 18.5&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 18.5&MemoryReq 0&Type 1
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 18.5&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 18.5&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0563()
{
  TestDescription("主驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0563");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0564()
{
  TestDescription("主驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0564");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 25&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 25&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 25&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 25&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0565()
{
  TestDescription("主驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0565");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 30&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 30&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetDrvTempStruct.Veh_SetDrvTemp:30&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetDrvTempStruct.Veh_SetDrvTemp:30&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 30&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 30&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0566()
{
  TestDescription("主驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0566");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:22"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:22//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 23&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 23&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 23&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 23&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0567()
{
  TestDescription("主驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0567");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0568()
{
  TestDescription("主驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0568");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 31.5&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 31.5&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempDownStruct.Veh_DriverTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempDownStruct.Veh_DriverTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 31.5&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 31.5&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0569()
{
  TestDescription("主驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0569");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempDownStruct.Veh_DriverTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempDownStruct.Veh_DriverTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0570()
{
  TestDescription("主驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0570");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:25"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:25//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 24&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 24&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempDownStruct.Veh_DriverTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempDownStruct.Veh_DriverTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 24&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 24&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0571()
{
  TestDescription("主驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0571");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempDownStruct.Veh_DriverTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempDownStruct.Veh_DriverTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0572()
{
  TestDescription("副驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0572");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:21"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:21//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 21.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 21.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempUpStruct.Veh_PsnTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempUpStruct.Veh_PsnTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 21.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 21.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0573()
{
  TestDescription("副驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0573");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempUpStruct.Veh_PsnTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempUpStruct.Veh_PsnTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0574()
{
  TestDescription("副驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0574");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetPsnTempStruct.Veh_SetPsnTemp:18&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetPsnTempStruct.Veh_SetPsnTemp:18&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0575()
{
  TestDescription("副驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0575");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetPsnTempStruct.Veh_SetPsnTemp:18&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetPsnTempStruct.Veh_SetPsnTemp:18&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0576()
{
  TestDescription("副驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0576");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:19"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:19//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 20&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 20&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempUpStruct.Veh_PsnTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempUpStruct.Veh_PsnTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 20&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 20&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0577()
{
  TestDescription("副驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0577");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempUpStruct.Veh_PsnTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempUpStruct.Veh_PsnTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0578()
{
  TestDescription("副驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0578");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:19"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:19//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 18.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempDownStruct.Veh_PsnTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempDownStruct.Veh_PsnTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 18.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0579()
{
  TestDescription("副驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0579");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempDownStruct.Veh_PsnTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempDownStruct.Veh_PsnTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0580()
{
  TestDescription("副驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0580");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 31&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 31&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempDownStruct.Veh_PsnTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempDownStruct.Veh_PsnTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 31&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 31&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0581()
{
  TestDescription("副驾空调温度调节（远控） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0581");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempDownStruct.Veh_PsnTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempDownStruct.Veh_PsnTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0582()
{
  TestDescription("二排左空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0582");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:19"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:19//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 19.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 19.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempUpStruct.Veh_RLTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempUpStruct.Veh_RLTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 19.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 19.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0583()
{
  TestDescription("二排左空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0583");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempUpStruct.Veh_RLTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempUpStruct.Veh_RLTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0584()
{
  TestDescription("二排左空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0584");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 30&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 30&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRLTempStruct.Veh_SetRLTemp:30&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRLTempStruct.Veh_SetRLTemp:30&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 30&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 30&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0585()
{
  TestDescription("二排左空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0585");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 30&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 30&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRLTempStruct.Veh_SetRLTemp:30&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRLTempStruct.Veh_SetRLTemp:30&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 30&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 30&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0586()
{
  TestDescription("二排左空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0586");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 19&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 19&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempUpStruct.Veh_RLTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempUpStruct.Veh_RLTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 19&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 19&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0587()
{
  TestDescription("二排左空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0587");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempUpStruct.Veh_RLTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempUpStruct.Veh_RLTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0588()
{
  TestDescription("二排左空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0588");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 31.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 31.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempDownStruct.Veh_RLTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempDownStruct.Veh_RLTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 31.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 31.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0589()
{
  TestDescription("二排左空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0589");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempDownStruct.Veh_RLTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempDownStruct.Veh_RLTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0590()
{
  TestDescription("二排左空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0590");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:19"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:19//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempDownStruct.Veh_RLTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempDownStruct.Veh_RLTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0591()
{
  TestDescription("二排左空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0591");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempDownStruct.Veh_RLTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempDownStruct.Veh_RLTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0592()
{
  TestDescription("二排右空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0592");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:25.5"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:25.5//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 26&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 26&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempUpStruct.Veh_RRTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempUpStruct.Veh_RRTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 26&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 26&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0593()
{
  TestDescription("二排右空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0593");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempUpStruct.Veh_RRTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempUpStruct.Veh_RRTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0594()
{
  TestDescription("二排右空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0594");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 27&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRRTempStruct.Veh_SetRRTemp:27&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRRTempStruct.Veh_SetRRTemp:27&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 27&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0595()
{
  TestDescription("二排右空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0595");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 27&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRRTempStruct.Veh_SetRRTemp:27&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRRTempStruct.Veh_SetRRTemp:27&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 27&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0596()
{
  TestDescription("二排右空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0596");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:23"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:23//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 24&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 24&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempUpStruct.Veh_RRTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempUpStruct.Veh_RRTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 24&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 24&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0597()
{
  TestDescription("二排右空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0597");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempUpStruct.Veh_RRTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempUpStruct.Veh_RRTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0598()
{
  TestDescription("二排右空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0598");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:27.5"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:27.5//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 27&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempDownStruct.Veh_RRTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempDownStruct.Veh_RRTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 27&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0599()
{
  TestDescription("二排右空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0599");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempDownStruct.Veh_RRTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempDownStruct.Veh_RRTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0600()
{
  TestDescription("二排右空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0600");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:27.5"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:27.5//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 26.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 26.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempDownStruct.Veh_RRTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempDownStruct.Veh_RRTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 26.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 26.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0601()
{
  TestDescription("二排右空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0601");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempDownStruct.Veh_RRTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempDownStruct.Veh_RRTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0602()
{
  TestDescription("三排空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0602");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:29"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:29//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 29.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 29.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 29.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 29.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0603()
{
  TestDescription("三排空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0603");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0604()
{
  TestDescription("三排空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0604");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_Set3rdRowTempStruct.Veh_Set3rdRowTemp:18&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_Set3rdRowTempStruct.Veh_Set3rdRowTemp:18&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0605()
{
  TestDescription("三排空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0605");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_Set3rdRowTempStruct.Veh_Set3rdRowTemp:18&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_Set3rdRowTempStruct.Veh_Set3rdRowTemp:18&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0606()
{
  TestDescription("三排空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0606");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 19&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 19&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 19&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 19&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0607()
{
  TestDescription("三排空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0607");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0608()
{
  TestDescription("三排空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0608");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:28"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:28//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 27.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 27.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 27.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 27.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0609()
{
  TestDescription("三排空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0609");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0610()
{
  TestDescription("三排空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0610");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:22"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:22//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 21&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 21&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 21&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 21&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0611()
{
  TestDescription("三排空调温度调节(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0611");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("SOAEngineInterSignalStruct.HVACTime 1"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:2"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_CHECK("SOAEngineInterSignalStruct.HVACTime 1"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("SOAEngineInterSignalStruct.HVACTime 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 0
  g_EM_SOAClient_Swc_SOA_CHECK("SOAEngineInterSignalStruct.HVACTime 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1
  gTC_CANTest_SOA_CheckReq("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1
}

testcase SYS_CDCU_wendudiaojie_0612()
{
  TestDescription("急速降温(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0612");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1
  gTC_CANTest_SOA_CheckReq("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0613()
{
  TestDescription("急速降温(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0613");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("SOAEngineInterSignalStruct.HVACTime 1"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:2 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_CHECK("SOAEngineInterSignalStruct.HVACTime 1"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("SOAEngineInterSignalStruct.HVACTime 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 0
  g_EM_SOAClient_Swc_SOA_CHECK("SOAEngineInterSignalStruct.HVACTime 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1
  gTC_CANTest_SOA_CheckReq("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1
}

testcase SYS_CDCU_jisushengwen_0614()
{
  TestDescription("急速升温(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-急速升温-0614");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1
  gTC_CANTest_SOA_CheckReq("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_jisushengwen_0615()
{
  TestDescription("急速升温(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-急速升温-0615");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("SOAEngineInterSignalStruct.HVACTime 1"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_CHECK("SOAEngineInterSignalStruct.HVACTime 1"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("SOAEngineInterSignalStruct.HVACTime 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 0
  g_EM_SOAClient_Swc_SOA_CHECK("SOAEngineInterSignalStruct.HVACTime 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1
  gTC_CANTest_SOA_CheckReq("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1
}

testcase SYS_CDCU_jisushengwen_0616()
{
  TestDescription("急速升温(远控)定时HVACTime关闭命令不影响HVACTime Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-急速升温-0616");
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:0"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("SOAEngineInterSignalStruct.HVACTime 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1
  g_EM_SOAClient_Swc_SOA_CHECK("SOAEngineInterSignalStruct.HVACTime 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1
  gTC_CANTest_SOA_CheckReq("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1
}

testcase SYS_CDCU_kongdiaoyewuHVACTime_0617()
{
  TestDescription("空调业务Time为0 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调业务HVACTime-0617");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("SOAEngineInterSignalStruct.HVACHVReq 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACHVReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:0"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:0 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  g_EM_SOAClient_Swc_SOA_CHECK("SOAEngineInterSignalStruct.HVACHVReq 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACHVReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaoyewuHVACTime_0618()
{
  TestDescription("空调业务Time为ff Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调业务HVACTime-0618");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("SOAEngineInterSignalStruct.HVACHVReq 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACHVReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:0xFFFF"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:0xFFFF //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  g_EM_SOAClient_Swc_SOA_CHECK("SOAEngineInterSignalStruct.HVACHVReq 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACHVReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("SOAEngineInterSignalStruct.HVACHVReq 1"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACHVReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("SOAEngineInterSignalStruct.HVACTime 2"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:3"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:3 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  g_EM_SOAClient_Swc_SOA_CHECK("SOAEngineInterSignalStruct.HVACHVReq 1"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACHVReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("SOAEngineInterSignalStruct.HVACTime 2"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("SOAEngineInterSignalStruct.HVACHVReq 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACHVReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("SOAEngineInterSignalStruct.HVACTime 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:0xFFFF"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:0xFFFF //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  g_EM_SOAClient_Swc_SOA_CHECK("SOAEngineInterSignalStruct.HVACHVReq 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACHVReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("SOAEngineInterSignalStruct.HVACTime 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("SOAEngineInterSignalStruct.HVACHVReq 1"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACHVReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("SOAEngineInterSignalStruct.HVACTime 9"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 9
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:10"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:10 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  g_EM_SOAClient_Swc_SOA_CHECK("SOAEngineInterSignalStruct.HVACHVReq 1"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACHVReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("SOAEngineInterSignalStruct.HVACTime 9"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACTime 9
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("SOAEngineInterSignalStruct.HVACHVReq 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACHVReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:0"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:0 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  g_EM_SOAClient_Swc_SOA_CHECK("SOAEngineInterSignalStruct.HVACHVReq 0"); // 预期结果 TC_CANTest SOA check SOAEngineInterSignalStruct.HVACHVReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0619()
{
  TestDescription("设置吹脸(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0619");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:1//Face
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0620()
{
  TestDescription("设置吹脸(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0620");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:3"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:3//Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0621()
{
  TestDescription("设置吹脸(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0621");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:6"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:6//Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0622()
{
  TestDescription("设置吹脸(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0622");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:6"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:6//Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0623()
{
  TestDescription("设置吹脸(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0623");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:2//Face_foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0624()
{
  TestDescription("设置吹脸(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0624");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:4"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:4//Foot_windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0625()
{
  TestDescription("设置吹脸(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0625");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:4"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:4//Foot_windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0626()
{
  TestDescription("设置吹脸(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0626");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:8"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:8//Face_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0627()
{
  TestDescription("设置吹脸(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0627");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:9"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:9//Face_Foot_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0628()
{
  TestDescription("设置吹脸(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0628");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:0xD"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:0xD//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0629()
{
  TestDescription("设置吹脸(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0629");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:0xE"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:0xE//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0630()
{
  TestDescription("设置吹脸(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0630");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:0xF"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:0xF//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0631()
{
  TestDescription("设置吹脚(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0631");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:3"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:3//Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3&MemoryReq 0//Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3&MemoryReq 0//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0632()
{
  TestDescription("设置吹脚(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0632");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:1//Face
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0633()
{
  TestDescription("设置吹脚(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0633");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:6"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:6//Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0634()
{
  TestDescription("设置吹脚(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0634");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:2//Face_foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0635()
{
  TestDescription("设置吹脚(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0635");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:4"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:4//Foot_windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0636()
{
  TestDescription("设置吹脚(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0636");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:8"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:8//Face_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0637()
{
  TestDescription("设置吹脚(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0637");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:9"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:9//Face_Foot_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0638()
{
  TestDescription("设置吹窗(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0638");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:6"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:6//Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 6&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6&MemoryReq 0//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 6&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6&MemoryReq 0//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0639()
{
  TestDescription("设置吹窗(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0639");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:1//Face
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0640()
{
  TestDescription("设置吹窗(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0640");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:1//Face
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0641()
{
  TestDescription("设置吹窗(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0641");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:2//Face_foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0642()
{
  TestDescription("设置吹窗(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0642");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:2//Face_foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0643()
{
  TestDescription("设置吹窗(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0643");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:4"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:4//Foot_windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0644()
{
  TestDescription("设置吹窗(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0644");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:8"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:8//Face_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0645()
{
  TestDescription("设置吹窗(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0645");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:9"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:9//Face_Foot_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0646()
{
  TestDescription("前排吹风模式设置(语音)(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0646");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0647()
{
  TestDescription("前排吹风模式设置(语音)(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0647");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Face_foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0648()
{
  TestDescription("前排吹风模式设置(语音)(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0648");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0649()
{
  TestDescription("前排吹风模式设置(语音)(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0649");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0650()
{
  TestDescription("前排吹风模式设置(语音)(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0650");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0651()
{
  TestDescription("前排吹风模式设置(语音)(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0651");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0652()
{
  TestDescription("前排吹风模式设置(语音)(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0652");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0653()
{
  TestDescription("设置吹脸(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0653");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:1//Face
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0654()
{
  TestDescription("设置吹脸(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0654");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:2//Face_Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 1//Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 1//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0655()
{
  TestDescription("设置吹脸(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0655");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:3"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:3//Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0656()
{
  TestDescription("设置吹脸(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0656");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:14"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:14//OFF
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0657()
{
  TestDescription("设置吹脚(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0657");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:3"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:3//Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 0//Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 0//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0658()
{
  TestDescription("设置吹脚(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0658");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:2//Face_Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0659()
{
  TestDescription("设置吹脚(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0659");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:1//Face
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0660()
{
  TestDescription("设置吹脚(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0660");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:14"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:14//OFF
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0661()
{
  TestDescription("二排吹风模式设置(语音)(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0661");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0662()
{
  TestDescription("二排吹风模式设置(语音)(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0662");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0663()
{
  TestDescription("二排吹风模式设置(语音)(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0663");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3//Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0664()
{
  TestDescription("二排吹风模式设置(语音)(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0664");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 13"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 13//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:13&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:13&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 13"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 13//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0665()
{
  TestDescription("二排吹风模式设置(语音)(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0665");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 14"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 14//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:14&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:14&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 14"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 14//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qiankongdiao_0666()
{
  TestDescription("打开前空调(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-前空调-0666");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnFrACStruct.TurnOnFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnFrACStruct.TurnOnFrAC 1//
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnFrACStruct.TurnOnFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnFrACStruct.TurnOnFrAC 1//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qiankongdiao_0667()
{
  TestDescription("关闭前空调(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-前空调-0667");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qiankongdiao_0668()
{
  TestDescription("关闭前空调(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-前空调-0668");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_houkongdiao_0669()
{
  TestDescription("打开后空调(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-后空调-0669");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnRrACStruct.TurnOnRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnRrACStruct.TurnOnRrAC 1//
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnRrACStruct.TurnOnRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnRrACStruct.TurnOnRrAC 1//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_houkongdiao_0670()
{
  TestDescription("关闭后空调(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-后空调-0670");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffRrACStruct.TurnOffRrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffRrACStruct.TurnOffRrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_houkongdiao_0671()
{
  TestDescription("打开后空调(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-后空调-0671");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnRrACStruct.TurnOnRrAC 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnRrACStruct.TurnOnRrAC 0//
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1&MemoryReq:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1&MemoryReq:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnRrACStruct.TurnOnRrAC 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnRrACStruct.TurnOnRrAC 0//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_houkongdiao_0672()
{
  TestDescription("关闭后空调(远控) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-后空调-0672");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffRrACStruct.TurnOffRrAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffRrACStruct.TurnOffRrAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qiankongdiaozidongmoshi_0673()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-前空调自动模式-0673");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 2//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_qiankongdiaozidongmoshi_0674()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-前空调自动模式-0674");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qiankongdiaozidongmoshi_0675()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-前空调自动模式-0675");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_houkongdiaozidongmoshi_0676()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-后空调自动模式-0676");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 2//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_houkongdiaozidongmoshi_0677()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-后空调自动模式-0677");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_houkongdiaozidongmoshi_0678()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-后空调自动模式-0678");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qianchushuang_0679()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-前除霜-0679");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_qianchushuang_0680()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-前除霜-0680");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qianchushuang_0681()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-前除霜-0681");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//Active
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//Active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_qianchushuang_0682()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-前除霜-0682");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//Active
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//Active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhinengchuwei_0683()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-智能除味-0683");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq("SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhinengchuwei_0684()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-智能除味-0684");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq("SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhinengchuwei_0685()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-智能除味-0685");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//Active
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//Active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhinengchuwei_0686()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-智能除味-0686");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//Active
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//Active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_houkongdiaowugantongfeng_0687()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-后空调无感通风-0687");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_houkongdiaowugantongfeng_0688()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-后空调无感通风-0688");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_houkongdiaowugantongfeng_0689()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-后空调无感通风-0689");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_houkongdiaowugantongfeng_0690()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-后空调无感通风-0690");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziganzao_0691()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自干燥-0691");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziganzao_0692()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自干燥-0692");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq("SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziganzao_0693()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自干燥-0693");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziganzao_0694()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自干燥-0694");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq("SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wenqutongbu_0695()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温区同步-0695");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetSyncStruct.SetSync 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetSyncStruct.Veh_SetSync:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetSyncStruct.Veh_SetSync:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetSyncStruct.SetSync 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wenqutongbu_0696()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温区同步-0696");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetSyncStruct.SetSync 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetSyncStruct.Veh_SetSync:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetSyncStruct.Veh_SetSync:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq("SetSyncStruct.SetSync 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wenqutongbu_0697()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温区同步-0697");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetSyncStruct.SetSync 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetSyncStruct.Veh_SetSync:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetSyncStruct.Veh_SetSync:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetSyncStruct.SetSync 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wenqutongbu_0698()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-温区同步-0698");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetSyncStruct.SetSync 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetSyncStruct.Veh_SetSync:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetSyncStruct.Veh_SetSync:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq("SetSyncStruct.SetSync 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0699()
{
  TestDescription("设置前空调风量(步进加) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0699");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:0"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:0//OFF
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0700()
{
  TestDescription("设置前空调风量(步进加) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0700");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:1"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:1//Level 1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0701()
{
  TestDescription("设置前空调风量(步进加) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0701");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:2"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:2//Level 2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0702()
{
  TestDescription("设置前空调风量(步进加) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0702");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:3"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:3//Level 3
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0703()
{
  TestDescription("设置前空调风量(步进加) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0703");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:4"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:4//Level 4
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0704()
{
  TestDescription("设置前空调风量(步进加) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0704");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:5"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:5//Level 5
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0705()
{
  TestDescription("设置前空调风量(步进加) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0705");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:6"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:6//Level 6
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0706()
{
  TestDescription("设置前空调风量(步进加) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0706");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:7"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:7//Level 7
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 8"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 8"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0707()
{
  TestDescription("设置前空调风量(步进加) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0707");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:8"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:8//Level 8
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 9"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 9"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0708()
{
  TestDescription("设置前空调风量(步进加) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0708");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:9"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:9//Level 9
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 10"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 10"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0709()
{
  TestDescription("设置前空调风量(步进加) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0709");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:10"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:10//Level 10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 10"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 10"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0710()
{
  TestDescription("设置前空调风量(目标设置) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0710");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 0&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:0&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:0&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 0&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0711()
{
  TestDescription("设置前空调风量(目标设置) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0711");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0712()
{
  TestDescription("设置前空调风量(目标设置) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0712");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 2"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 2"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0713()
{
  TestDescription("设置前空调风量(目标设置) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0713");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0714()
{
  TestDescription("设置前空调风量(目标设置) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0714");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0715()
{
  TestDescription("设置前空调风量(目标设置) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0715");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0716()
{
  TestDescription("设置前空调风量(目标设置) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0716");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0717()
{
  TestDescription("设置前空调风量(目标设置) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0717");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0718()
{
  TestDescription("设置前空调风量(目标设置) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0718");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 8"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:8&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:8&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 8"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0719()
{
  TestDescription("设置前空调风量(目标设置) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0719");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 9"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:9&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:9&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 9"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0720()
{
  TestDescription("设置前空调风量(目标设置) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0720");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 10"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:10&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:10&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 10"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0721()
{
  TestDescription("设置前空调风量(步进减) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0721");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:10"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:10//Level 10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 9&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 9&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0722()
{
  TestDescription("设置前空调风量(步进减) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0722");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:9"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:9//Level 9
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 8&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 8&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0723()
{
  TestDescription("设置前空调风量(步进减) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0723");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:8"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:8//Level 8
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0724()
{
  TestDescription("设置前空调风量(步进减) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0724");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:7"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:7//Level 7
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0725()
{
  TestDescription("设置前空调风量(步进减) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0725");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:6"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:6//Level 6
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0726()
{
  TestDescription("设置前空调风量(步进减) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0726");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:5"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:5//Level 5
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0727()
{
  TestDescription("设置前空调风量(步进减) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0727");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:4"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:4//Level 4
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0728()
{
  TestDescription("设置前空调风量(步进减) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0728");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:3"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:3//Level 3
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 2"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 2"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0729()
{
  TestDescription("设置前空调风量(步进减) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0729");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:2"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:2//Level 2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0730()
{
  TestDescription("设置前空调风量(步进减) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0730");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:1"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:1//Level 1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0731()
{
  TestDescription("设后空调风量(步进加) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0731");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:0"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:0//Level 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0732()
{
  TestDescription("设后空调风量(步进加) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0732");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:1"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:1//Level 1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 2&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 2&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0733()
{
  TestDescription("设后空调风量(步进加) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0733");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:2"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:2//Level 2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0734()
{
  TestDescription("设后空调风量(步进加) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0734");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:3"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:3//Level 3
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0735()
{
  TestDescription("设后空调风量(步进加) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0735");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:4"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:4//Level 4
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0736()
{
  TestDescription("设后空调风量(步进加) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0736");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:5"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:5//Level 5
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0737()
{
  TestDescription("设后空调风量(目标设置) Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0737");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlRrWindSpdRespStruct.Veh_CtrlRrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlRrWindSpdRespStruct.Veh_CtrlRrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlRrWindSpdStruct.Veh_CtrlRrWindSpd:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlRrWindSpdStruct.Veh_CtrlRrWindSpd:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlRrWindSpdRespStruct.Veh_CtrlRrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlRrWindSpdRespStruct.Veh_CtrlRrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0738()
{
  TestDescription("设后空调风量（步进减） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0738");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:5"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:5//Level 5
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 4&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 4&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 4&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 4&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0739()
{
  TestDescription("设后空调风量（步进减） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0739");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:4"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:4//Level 4
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 3&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 3&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0740()
{
  TestDescription("设后空调风量（步进减） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0740");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:3"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:3//Level 3
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 2&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 2&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0741()
{
  TestDescription("设后空调风量（步进减） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0741");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:2"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:2//Level 2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0742()
{
  TestDescription("设后空调风量（步进减） Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0742");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:1"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:1//Level 1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_neixunhuan_0743()
{
  TestDescription("内循环 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-内循环-0743");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetAirIntakeStruct.SetAirIntake 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 1&MemoryReq 0//
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetAirIntakeStruct.Veh_SetAirIntake:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetAirIntakeStruct.Veh_SetAirIntake:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//内循环
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq("SetAirIntakeStruct.SetAirIntake 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 1&MemoryReq 0//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_neixunhuan_0744()
{
  TestDescription("内循环 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-内循环-0744");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetAirIntakeStruct.SetAirIntake 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 1&MemoryReq 1//
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetAirIntakeStruct.Veh_SetAirIntake:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetAirIntakeStruct.Veh_SetAirIntake:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//内循环
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq("SetAirIntakeStruct.SetAirIntake 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 1&MemoryReq 1//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_waixunhuan_0745()
{
  TestDescription("外循环 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-外循环-0745");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetAirIntakeStruct.SetAirIntake 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 2&MemoryReq 0//
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetAirIntakeStruct.Veh_SetAirIntake:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetAirIntakeStruct.Veh_SetAirIntake:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//外循环
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq("SetAirIntakeStruct.SetAirIntake 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 2&MemoryReq 0//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_waixunhuan_0746()
{
  TestDescription("外循环 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-外循环-0746");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetAirIntakeStruct.SetAirIntake 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 2&MemoryReq 1//
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetAirIntakeStruct.Veh_SetAirIntake:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetAirIntakeStruct.Veh_SetAirIntake:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//外循环
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq("SetAirIntakeStruct.SetAirIntake 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 2&MemoryReq 1//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_shezhikongdiaojienengmoshi_0747()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-设置空调节能模式-0747");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq("setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_shezhikongdiaojienengmoshi_0748()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-设置空调节能模式-0748");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq("setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_shezhikongdiaojienengmoshi_0749()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-设置空调节能模式-0749");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq("setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_shezhikongdiaojienengmoshi_0750()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-设置空调节能模式-0750");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq("setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_AQSgongneng_0751()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-AQS功能-0751");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_AQSgongneng_0752()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-AQS功能-0752");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_AQSgongneng_0753()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-AQS功能-0753");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_AQSgongneng_0754()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-AQS功能-0754");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongqijinghuagongneng_0755()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空气净化功能-0755");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongqijinghuagongneng_0756()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空气净化功能-0756");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongqijinghuagongneng_0757()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空气净化功能-0757");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongqijinghuagongneng_0758()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空气净化功能-0758");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaolengnuantongfenggongneng_0759()
{
  TestDescription("打开空调冷暖通风功能 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调冷暖通风功能-0759");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOFFHCVStruct.TurnOnOFFHCV 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 1&MemoryReq 0//CoolingOn
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//CoolingOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnOFFHCVStruct.TurnOnOFFHCV 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 1&MemoryReq 0//CoolingOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaolengnuantongfenggongneng_0760()
{
  TestDescription("打开空调冷暖通风功能 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调冷暖通风功能-0760");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOFFHCVStruct.TurnOnOFFHCV 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 2&MemoryReq 1//HeatOn
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//HeatOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOFFHCVStruct.TurnOnOFFHCV 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 2&MemoryReq 1//HeatOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaolengnuantongfenggongneng_0761()
{
  TestDescription("打开空调冷暖通风功能 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调冷暖通风功能-0761");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOFFHCVStruct.TurnOnOFFHCV 3"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 3//VentilateOn
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//VentilateOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOFFHCVStruct.TurnOnOFFHCV 3"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 3//VentilateOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaolengnuantongfenggongneng_0762()
{
  TestDescription("打开空调冷暖通风功能 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调冷暖通风功能-0762");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOFFHCVStruct.TurnOnOFFHCV 4"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 4//AutoHCVOn
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//AutoHCVOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOFFHCVStruct.TurnOnOFFHCV 4"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 4//AutoHCVOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0763()
{
  TestDescription("主驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0763");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_NM.I_LDCU_NMReq_CDCU 1"); // 测试步骤 TC_CANTest SET I_LDCU_NM.I_LDCU_NMReq_CDCU 1 //网络唤醒维持帧
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 18.5&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 18.5&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 18.5&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 18.5&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0764()
{
  TestDescription("主驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0764");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0765()
{
  TestDescription("主驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0765");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 25&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 25&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 25&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 25&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0766()
{
  TestDescription("主驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0766");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 30&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 30&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetDrvTempStruct.Veh_SetDrvTemp:30&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetDrvTempStruct.Veh_SetDrvTemp:30&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 30&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 30&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0767()
{
  TestDescription("主驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0767");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:22"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:22//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 23&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 23&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 23&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 23&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0768()
{
  TestDescription("主驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0768");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0769()
{
  TestDescription("主驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0769");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 31.5&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 31.5&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempDownStruct.Veh_DriverTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempDownStruct.Veh_DriverTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 31.5&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 31.5&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0770()
{
  TestDescription("主驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0770");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempDownStruct.Veh_DriverTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempDownStruct.Veh_DriverTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0771()
{
  TestDescription("主驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0771");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:25"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:25//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 24&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 24&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempDownStruct.Veh_DriverTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempDownStruct.Veh_DriverTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 24&MemoryReq 0&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 24&MemoryReq 0&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0772()
{
  TestDescription("主驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0772");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempDownStruct.Veh_DriverTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempDownStruct.Veh_DriverTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 1"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0773()
{
  TestDescription("副驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0773");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:21"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:21//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 21.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 21.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempUpStruct.Veh_PsnTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempUpStruct.Veh_PsnTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 21.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 21.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0774()
{
  TestDescription("副驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0774");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempUpStruct.Veh_PsnTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempUpStruct.Veh_PsnTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0775()
{
  TestDescription("副驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0775");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetPsnTempStruct.Veh_SetPsnTemp:18&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetPsnTempStruct.Veh_SetPsnTemp:18&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0776()
{
  TestDescription("副驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0776");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetPsnTempStruct.Veh_SetPsnTemp:18&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetPsnTempStruct.Veh_SetPsnTemp:18&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0777()
{
  TestDescription("副驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0777");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:19"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:19//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 20&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 20&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempUpStruct.Veh_PsnTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempUpStruct.Veh_PsnTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 20&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 20&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0778()
{
  TestDescription("副驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0778");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempUpStruct.Veh_PsnTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempUpStruct.Veh_PsnTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0779()
{
  TestDescription("副驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0779");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:19"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:19//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 18.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempDownStruct.Veh_PsnTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempDownStruct.Veh_PsnTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 18.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0780()
{
  TestDescription("副驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0780");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempDownStruct.Veh_PsnTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempDownStruct.Veh_PsnTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0781()
{
  TestDescription("副驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0781");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 31&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 31&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempDownStruct.Veh_PsnTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempDownStruct.Veh_PsnTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 31&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 31&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0782()
{
  TestDescription("副驾空调温度调节（远控） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0782");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempDownStruct.Veh_PsnTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempDownStruct.Veh_PsnTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0783()
{
  TestDescription("二排左空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0783");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:19"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:19//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 19.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 19.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempUpStruct.Veh_RLTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempUpStruct.Veh_RLTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 19.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 19.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0784()
{
  TestDescription("二排左空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0784");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempUpStruct.Veh_RLTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempUpStruct.Veh_RLTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0785()
{
  TestDescription("二排左空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0785");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 30&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 30&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRLTempStruct.Veh_SetRLTemp:30&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRLTempStruct.Veh_SetRLTemp:30&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 30&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 30&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0786()
{
  TestDescription("二排左空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0786");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 30&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 30&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRLTempStruct.Veh_SetRLTemp:30&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRLTempStruct.Veh_SetRLTemp:30&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 30&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 30&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0787()
{
  TestDescription("二排左空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0787");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 19&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 19&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempUpStruct.Veh_RLTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempUpStruct.Veh_RLTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 19&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 19&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0788()
{
  TestDescription("二排左空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0788");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempUpStruct.Veh_RLTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempUpStruct.Veh_RLTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0789()
{
  TestDescription("二排左空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0789");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 31.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 31.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempDownStruct.Veh_RLTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempDownStruct.Veh_RLTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 31.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 31.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0790()
{
  TestDescription("二排左空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0790");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempDownStruct.Veh_RLTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempDownStruct.Veh_RLTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0791()
{
  TestDescription("二排左空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0791");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:19"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:19//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempDownStruct.Veh_RLTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempDownStruct.Veh_RLTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0792()
{
  TestDescription("二排左空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0792");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempDownStruct.Veh_RLTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempDownStruct.Veh_RLTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0793()
{
  TestDescription("二排右空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0793");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:25.5"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:25.5//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 26&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 26&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempUpStruct.Veh_RRTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempUpStruct.Veh_RRTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 26&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 26&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0794()
{
  TestDescription("二排右空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0794");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempUpStruct.Veh_RRTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempUpStruct.Veh_RRTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0795()
{
  TestDescription("二排右空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0795");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 27&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRRTempStruct.Veh_SetRRTemp:27&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRRTempStruct.Veh_SetRRTemp:27&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 27&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0796()
{
  TestDescription("二排右空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0796");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 27&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRRTempStruct.Veh_SetRRTemp:27&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRRTempStruct.Veh_SetRRTemp:27&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 27&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0797()
{
  TestDescription("二排右空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0797");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:23"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:23//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 24&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 24&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempUpStruct.Veh_RRTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempUpStruct.Veh_RRTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 24&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 24&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0798()
{
  TestDescription("二排右空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0798");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempUpStruct.Veh_RRTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempUpStruct.Veh_RRTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0799()
{
  TestDescription("二排右空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0799");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:27.5"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:27.5//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 27&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempDownStruct.Veh_RRTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempDownStruct.Veh_RRTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 27&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0800()
{
  TestDescription("二排右空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0800");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempDownStruct.Veh_RRTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempDownStruct.Veh_RRTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0801()
{
  TestDescription("二排右空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0801");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:27.5"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:27.5//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 26.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 26.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempDownStruct.Veh_RRTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempDownStruct.Veh_RRTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 26.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 26.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0802()
{
  TestDescription("二排右空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0802");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempDownStruct.Veh_RRTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempDownStruct.Veh_RRTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0803()
{
  TestDescription("三排空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0803");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:29"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:29//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 29.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 29.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 29.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 29.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0804()
{
