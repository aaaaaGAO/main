  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0238");
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0239()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0239");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0240()
{
  TestDescription("RDCU_RRDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0240");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0241()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0241");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0242()
{
  TestDescription("LDCU_RLWinPosStFB ＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0242");
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0243()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0243");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0244()
{
  TestDescription("RDCU_PLGSts！=Closed Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0244");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 3"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0245()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0245");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0246()
{
  TestDescription("RDCU_PLGSts！=Closed Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0246");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 2"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0247()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0247");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0248()
{
  TestDescription("RDCU_PLGSts！=Closed Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0248");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 4"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0249()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0249");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0250()
{
  TestDescription("100%>=RoofPosValue>0% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0250");
  g_CAN_Bus_Swc_Set("I_RDCU_SunRoofWindowCtrl.I_RoofPosValue 0"); // 测试步骤 TC_CANTest SET I_RDCU_SunRoofWindowCtrl.I_RoofPosValue 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_CAN_Bus_Swc_Set("I_RDCU_SunRoofWindowCtrl.I_RoofPosValue 100"); // 测试步骤 TC_CANTest SET I_RDCU_SunRoofWindowCtrl.I_RoofPosValue 100
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0251()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0251");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0252()
{
  TestDescription("100%>=RoofPosValue>0% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0252");
  g_CAN_Bus_Swc_Set("I_RDCU_SunRoofWindowCtrl.I_RoofPosValue 0"); // 测试步骤 TC_CANTest SET I_RDCU_SunRoofWindowCtrl.I_RoofPosValue 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_CAN_Bus_Swc_Set("I_RDCU_SunRoofWindowCtrl.I_RoofPosValue 50"); // 测试步骤 TC_CANTest SET I_RDCU_SunRoofWindowCtrl.I_RoofPosValue 50
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0253()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0253");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_CAN_Bus_Swc_Set("I_RDCU_SunRoofWindowCtrl.I_RoofPosValue 0"); // 测试步骤 TC_CANTest SET I_RDCU_SunRoofWindowCtrl.I_RoofPosValue 0
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0254()
{
  TestDescription("LDCU_PowerMode==Remote ON -> Local ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0254");
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 7//HVAC_HIGH_TEMP_STOP_IGON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 7//HVAC_HIGH_TEMP_STOP_IGON
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0255()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0255");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0256()
{
  TestDescription("RDCU_PLGSts！=Closed Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0256");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 2"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0257()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0257");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0258()
{
  TestDescription("ACSysState Eventgroup 信息 ACPowerSt==OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0258");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 4 traceback2//HVAC_HIGH_TEMP_STOP_AC_ERROR
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt 0 sleep2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt 0 sleep2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 4 traceback2//HVAC_HIGH_TEMP_STOP_AC_ERROR
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0259()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0259");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0260()
{
  TestDescription("ACSysState Eventgroup 信息 DisinfSt==OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0260");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:0"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:0//OFF
  g_EM_SOAClient_Swc_SOA_CHECKNotRec("Veh_HVACRemotePushStruct.Veh_DisinfStPush timeoutS3"); // 预期结果 TC_CANTest SOA CheckNotRec Veh_HVACRemotePushStruct.Veh_DisinfStPush timeoutS3
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0261()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0261");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0262()
{
  TestDescription("LDCU_EVSysReadySt==Not ready Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0262");
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 8"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 8//HVAC_HIGH_TEMP_STOP_IGOFF
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 0"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 8"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 8//HVAC_HIGH_TEMP_STOP_IGOFF
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("1"); // 测试步骤 TC_Sleep 1
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0263()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0263");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0264()
{
  TestDescription("LDCU_dstBatDisp ≤ 80KM Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0264");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 80"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 80
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0265()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0265");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0266()
{
  TestDescription("LDCU_ChrgConnSt_Disp=AC Charge connector connected Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0266");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0267()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0267");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0268()
{
  TestDescription("LDCU_dstBatDisp 信 号 丢 失 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0268");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("1"); // 测试步骤 TC_Sleep 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  g_CAN_Bus_Swc_Disable("I_LDCU_SysStDisp1"); // 测试步骤 TC_CANTest Disable I_LDCU_SysStDisp1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0269()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0269");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0270()
{
  TestDescription("AcClrSt:6ERROR Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0270");
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:6"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:6
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("1"); // 测试步骤 TC_Sleep 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 8"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 8//HVAC_CLEAN_EXCEPTION_LOW_SOC
  g_CAN_Bus_Swc_Disable("I_LDCU_SysStDisp1"); // 测试步骤 TC_CANTest Disable I_LDCU_SysStDisp1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 8"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 8//HVAC_CLEAN_EXCEPTION_LOW_SOC
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0271()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0271");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0272()
{
  TestDescription("LDCU_ChrgConnSt_Disp=DC Charge connector connected Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0272");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0273()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0273");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0274()
{
  TestDescription("LDCU_DriverDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0274");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0275()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0275");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0276()
{
  TestDescription("LDCU_FLWinPosStFB ＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0276");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0277()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0277");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0278()
{
  TestDescription("LDCU_RLDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0278");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0279()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0279");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0280()
{
  TestDescription("RDCU_FRWinPosStFB ＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0280");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0281()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0281");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0282()
{
  TestDescription("RDCU_PsngrDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0282");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0283()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0283");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0284()
{
  TestDescription("RDCU_RRWinPosStFB＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0284");
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0285()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0285");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0286()
{
  TestDescription("RDCU_RRDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0286");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0287()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0287");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0288()
{
  TestDescription("LDCU_RLWinPosStFB ＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0288");
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0289()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0289");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0290()
{
  TestDescription("RDCU_PLGSts！=Closed Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0290");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 3"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0291()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0291");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0292()
{
  TestDescription("LDCU_PowerMode==Remote ON -> Local ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0292");
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 3"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 3//HVAC_CLEAN_EXCEPTION_LOCAL_IGON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 3"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 3//HVAC_CLEAN_EXCEPTION_LOCAL_IGON
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0293()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0293");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0294()
{
  TestDescription("RDCU_PLGSts！=Closed Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0294");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 4"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0295()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0295");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0296()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=1//antivirus mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0296");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:1//antivirus mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0297()
{
  TestDescription("RDCU_PLGSts！=Closed Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0297");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 2"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0298()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0298");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0299()
{
  TestDescription("LDCU_dstBatDisp ≤ 80KM Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0299");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 80"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 80
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0300()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0300");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0301()
{
  TestDescription("LDCU_ChrgConnSt_Disp=AC Charge connector connected Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0301");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0302()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0302");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0303()
{
  TestDescription("LDCU_dstBatDisp 信 号 丢 失 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0303");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("1"); // 测试步骤 TC_Sleep 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  g_CAN_Bus_Swc_Disable("I_LDCU_SysStDisp1"); // 测试步骤 TC_CANTest Disable I_LDCU_SysStDisp1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0304()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0304");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0305()
{
  TestDescription("LDCU_ChrgConnSt_Disp=DC Charge connector connected Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0305");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0306()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0306");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0307()
{
  TestDescription("LDCU_DriverDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0307");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0308()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0308");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0309()
{
  TestDescription("LDCU_FLWinPosStFB ＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0309");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0310()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0310");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0311()
{
  TestDescription("LDCU_RLDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0311");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0312()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0312");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0313()
{
  TestDescription("RDCU_FRWinPosStFB ＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0313");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0314()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0314");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0315()
{
  TestDescription("RDCU_PsngrDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0315");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0316()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0316");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0317()
{
  TestDescription("RDCU_RRWinPosStFB＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0317");
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0318()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0318");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0319()
{
  TestDescription("RDCU_RRDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0319");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0320()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0320");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0321()
{
  TestDescription("LDCU_RLWinPosStFB ＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0321");
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0322()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0322");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0323()
{
  TestDescription("RDCU_PLGSts！=Closed Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0323");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 3"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0324()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0324");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0325()
{
  TestDescription("LDCU_PowerMode==Remote ON -> Local ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0325");
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 3"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 3//HVAC_CLEAN_EXCEPTION_LOCAL_IGON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 3"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 3//HVAC_CLEAN_EXCEPTION_LOCAL_IGON
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0326()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0326");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0327()
{
  TestDescription("RDCU_PLGSts！=Closed Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0327");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 4"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0328()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0328");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0329()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=2//cooling mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0329");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:2"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:2//cooling mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0330()
{
  TestDescription("RDCU_PLGSts！=Closed Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0330");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 2"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0331()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0331");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0332()
{
  TestDescription("LDCU_dstBatDisp ≤ 80KM Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0332");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 80"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 80
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0333()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0333");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0334()
{
  TestDescription("LDCU_ChrgConnSt_Disp=AC Charge connector connected Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0334");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0335()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0335");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0336()
{
  TestDescription("LDCU_dstBatDisp 信 号 丢 失 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0336");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("1"); // 测试步骤 TC_Sleep 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  g_CAN_Bus_Swc_Disable("I_LDCU_SysStDisp1"); // 测试步骤 TC_CANTest Disable I_LDCU_SysStDisp1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0337()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0337");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0338()
{
  TestDescription("LDCU_ChrgConnSt_Disp=DC Charge connector connected Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0338");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0339()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0339");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0340()
{
  TestDescription("LDCU_DriverDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0340");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0341()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0341");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0342()
{
  TestDescription("LDCU_FLWinPosStFB ＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0342");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0343()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0343");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0344()
{
  TestDescription("LDCU_RLDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0344");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0345()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0345");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0346()
{
  TestDescription("RDCU_FRWinPosStFB ＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0346");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0347()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0347");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0348()
{
  TestDescription("RDCU_PsngrDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0348");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0349()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0349");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0350()
{
  TestDescription("RDCU_RRWinPosStFB＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0350");
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0351()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0351");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0352()
{
  TestDescription("RDCU_RRDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0352");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0353()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0353");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0354()
{
  TestDescription("LDCU_RLWinPosStFB ＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0354");
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0355()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0355");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0356()
{
  TestDescription("RDCU_PLGSts！=Closed Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0356");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 3"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0357()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0357");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0358()
{
  TestDescription("LDCU_PowerMode==Remote ON -> Local ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0358");
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 3"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 3//HVAC_CLEAN_EXCEPTION_LOCAL_IGON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 3"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 3//HVAC_CLEAN_EXCEPTION_LOCAL_IGON
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0359()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0359");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0360()
{
  TestDescription("RDCU_PLGSts！=Closed Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0360");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 4"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0361()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0361");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0362()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=3//dry mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0362");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:3"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:3//dry mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0363()
{
  TestDescription("RDCU_PLGSts！=Closed Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0363");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 2"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0364()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0364");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0365()
{
  TestDescription("LDCU_dstBatDisp ≤ 80KM Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0365");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 80"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 80
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0366()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0366");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0367()
{
  TestDescription("LDCU_ChrgConnSt_Disp=AC Charge connector connected Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0367");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0368()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0368");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0369()
{
  TestDescription("LDCU_dstBatDisp 信 号 丢 失 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0369");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("1"); // 测试步骤 TC_Sleep 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
  g_CAN_Bus_Swc_Disable("I_LDCU_SysStDisp1"); // 测试步骤 TC_CANTest Disable I_LDCU_SysStDisp1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 7"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 7//HVAC_CLEAN_EXCEPTION_LOW_SOC
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0370()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0370");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0371()
{
  TestDescription("LDCU_ChrgConnSt_Disp=DC Charge connector connected Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0371");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 6"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 6//HVAC_CLEAN_EXCEPTION_CHARGE_PORT_CONNECTED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0372()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0372");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0373()
{
  TestDescription("LDCU_DriverDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0373");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0374()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0374");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0375()
{
  TestDescription("LDCU_FLWinPosStFB ＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0375");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0376()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0376");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0377()
{
  TestDescription("LDCU_RLDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0377");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0378()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0378");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0379()
{
  TestDescription("RDCU_FRWinPosStFB ＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0379");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0380()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0380");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0381()
{
  TestDescription("RDCU_PsngrDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0381");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0382()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0382");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0383()
{
  TestDescription("RDCU_RRWinPosStFB＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0383");
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0384()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0384");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0385()
{
  TestDescription("RDCU_RRDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0385");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0386()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0386");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0387()
{
  TestDescription("LDCU_RLWinPosStFB ＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0387");
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 4 traceback2//HVAC_CLEAN_EXCEPTION_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0388()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0388");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0389()
{
  TestDescription("RDCU_PLGSts！=Closed Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0389");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_RRDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 3"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0390()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0390");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0391()
{
  TestDescription("LDCU_PowerMode==Remote ON -> Local ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0391");
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 3"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 3//HVAC_CLEAN_EXCEPTION_LOCAL_IGON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 3"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 3//HVAC_CLEAN_EXCEPTION_LOCAL_IGON
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0392()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0392");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0393()
{
  TestDescription("RDCU_PLGSts！=Closed Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0393");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 4"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0394()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0394");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0395()
{
  TestDescription("空调自清洁远控功能运行中 AcClrSt=4//wind mode");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0395");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.AcClrSt:4"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.AcClrSt:4//wind mode
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjiegongnengzhuangtaiyuanchengtuisong_0396()
{
  TestDescription("RDCU_PLGSts！=Closed Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁功能状态远程推送-0396");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 2"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_AcClrPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_AcClrPush 5//HVAC_CLEAN_EXCEPTION_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0397()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0397");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("I_LDCU_NM.I_LDCU_NMReq_CDCU 1"); // 测试步骤 TC_CANTest SET I_LDCU_NM.I_LDCU_NMReq_CDCU 1 //网络唤醒维持帧
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0398()
{
  TestDescription("LDCU_dstBatDisp≤100 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0398");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 2//HVAC_HIGH_TEMP_STOP_LOW_SOC
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 50"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 50
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 2//HVAC_HIGH_TEMP_STOP_LOW_SOC
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0399()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0399");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0400()
{
  TestDescription("LDCU_ChrgConnSt_Disp=AC Charge connector  connected Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0400");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 3"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 3//HVAC_HIGH_TEMP_STOP_SLOW_CHARGING
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 3"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 3//HVAC_HIGH_TEMP_STOP_SLOW_CHARGING
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0401()
{
  TestDescription("打开高温抑菌 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0401");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
