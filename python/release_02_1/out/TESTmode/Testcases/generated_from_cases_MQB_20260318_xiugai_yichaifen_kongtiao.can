  TestDescription("三排空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0804");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0805()
{
  TestDescription("三排空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0805");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_Set3rdRowTempStruct.Veh_Set3rdRowTemp:18&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_Set3rdRowTempStruct.Veh_Set3rdRowTemp:18&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0806()
{
  TestDescription("三排空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0806");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_Set3rdRowTempStruct.Veh_Set3rdRowTemp:18&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_Set3rdRowTempStruct.Veh_Set3rdRowTemp:18&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0807()
{
  TestDescription("三排空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0807");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 19&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 19&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 19&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 19&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0808()
{
  TestDescription("三排空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0808");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0809()
{
  TestDescription("三排空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0809");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:28"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:28//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 27.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 27.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 27.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 27.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0810()
{
  TestDescription("三排空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0810");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0811()
{
  TestDescription("三排空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0811");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:22"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:22//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 21&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 21&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 21&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 21&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojie_0812()
{
  TestDescription("三排空调温度调节(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温度调节-0812");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_jisujiangwen_0813()
{
  TestDescription("急速降温(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-急速降温-0813");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1
  gTC_CANTest_SOA_CheckReq("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_jisujiangwen_0814()
{
  TestDescription("急速降温(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-急速降温-0814");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_jisushengwen_0815()
{
  TestDescription("急速升温(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-急速升温-0815");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1
  gTC_CANTest_SOA_CheckReq("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_jisushengwen_0816()
{
  TestDescription("急速升温(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-急速升温-0816");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0817()
{
  TestDescription("设置吹脸(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0817");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:1//Face
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0818()
{
  TestDescription("设置吹脸(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0818");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:3"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:3//Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0819()
{
  TestDescription("设置吹脸(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0819");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:6"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:6//Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0820()
{
  TestDescription("设置吹脸(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0820");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:6"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:6//Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0821()
{
  TestDescription("设置吹脸(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0821");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:2//Face_foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0822()
{
  TestDescription("设置吹脸(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0822");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:4"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:4//Foot_windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0823()
{
  TestDescription("设置吹脸(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0823");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:4"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:4//Foot_windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0824()
{
  TestDescription("设置吹脸(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0824");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:8"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:8//Face_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0825()
{
  TestDescription("设置吹脸(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0825");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:9"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:9//Face_Foot_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0826()
{
  TestDescription("设置吹脸(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0826");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:0xD"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:0xD//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0827()
{
  TestDescription("设置吹脸(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0827");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:0xE"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:0xE//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0828()
{
  TestDescription("设置吹脸(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0828");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:0xF"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:0xF//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0829()
{
  TestDescription("设置吹脚(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0829");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:3"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:3//Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3&MemoryReq 0//Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3&MemoryReq 0//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0830()
{
  TestDescription("设置吹脚(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0830");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:1//Face
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0831()
{
  TestDescription("设置吹脚(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0831");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:6"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:6//Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0832()
{
  TestDescription("设置吹脚(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0832");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:2//Face_foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0833()
{
  TestDescription("设置吹脚(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0833");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:4"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:4//Foot_windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0834()
{
  TestDescription("设置吹脚(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0834");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:8"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:8//Face_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0835()
{
  TestDescription("设置吹脚(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0835");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:9"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:9//Face_Foot_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0836()
{
  TestDescription("设置吹窗(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0836");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:6"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:6//Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 6&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6&MemoryReq 0//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 6&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6&MemoryReq 0//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0837()
{
  TestDescription("设置吹窗(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0837");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:1//Face
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0838()
{
  TestDescription("设置吹窗(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0838");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:1//Face
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0839()
{
  TestDescription("设置吹窗(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0839");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:2//Face_foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0840()
{
  TestDescription("设置吹窗(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0840");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:2//Face_foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0841()
{
  TestDescription("设置吹窗(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0841");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:4"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:4//Foot_windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0842()
{
  TestDescription("设置吹窗(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0842");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:8"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:8//Face_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0843()
{
  TestDescription("设置吹窗(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0843");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:9"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:9//Face_Foot_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0844()
{
  TestDescription("前排吹风模式设置(语音)(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0844");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0845()
{
  TestDescription("前排吹风模式设置(语音)(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0845");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Face_foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0846()
{
  TestDescription("前排吹风模式设置(语音)(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0846");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0847()
{
  TestDescription("前排吹风模式设置(语音)(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0847");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0848()
{
  TestDescription("前排吹风模式设置(语音)(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0848");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0849()
{
  TestDescription("前排吹风模式设置(语音)(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0849");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0850()
{
  TestDescription("前排吹风模式设置(语音)(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0850");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0851()
{
  TestDescription("设置吹脸(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0851");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:1//Face
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0852()
{
  TestDescription("设置吹脸(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0852");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:2//Face_Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 1//Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 1//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0853()
{
  TestDescription("设置吹脸(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0853");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:3"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:3//Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0854()
{
  TestDescription("设置吹脸(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0854");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:14"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:14//OFF
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0855()
{
  TestDescription("设置吹脚(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0855");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:3"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:3//Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 0//Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 0//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0856()
{
  TestDescription("设置吹脚(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0856");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:2//Face_Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0857()
{
  TestDescription("设置吹脚(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0857");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:1//Face
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0858()
{
  TestDescription("设置吹脚(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0858");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:14"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:14//OFF
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0859()
{
  TestDescription("二排吹风模式设置(语音)(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0859");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0860()
{
  TestDescription("二排吹风模式设置(语音)(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0860");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0861()
{
  TestDescription("二排吹风模式设置(语音)(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0861");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3//Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0862()
{
  TestDescription("二排吹风模式设置(语音)(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0862");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 13"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 13//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:13&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:13&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 13"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 13//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshi_0863()
{
  TestDescription("二排吹风模式设置(语音)(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式-0863");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 14"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 14//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:14&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:14&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 14"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 14//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qiankongdiao_0864()
{
  TestDescription("打开前空调(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-前空调-0864");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnFrACStruct.TurnOnFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnFrACStruct.TurnOnFrAC 1//
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnFrACStruct.TurnOnFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnFrACStruct.TurnOnFrAC 1//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_qiankongdiao_0865()
{
  TestDescription("关闭前空调(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-前空调-0865");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qiankongdiao_0866()
{
  TestDescription("关闭前空调(远控) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-前空调-0866");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qiankongdiaozidongmoshi_0867()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-前空调自动模式-0867");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 2//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_qiankongdiaozidongmoshi_0868()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-前空调自动模式-0868");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qiankongdiaozidongmoshi_0869()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-前空调自动模式-0869");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_houkongdiaozidongmoshi_0870()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-后空调自动模式-0870");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 2//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_houkongdiaozidongmoshi_0871()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-后空调自动模式-0871");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_houkongdiaozidongmoshi_0872()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-后空调自动模式-0872");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.Veh_TurnOnOffRrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffRrAutoACStruct.TurnOnOffRrAutoAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qianchushuang_0873()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-前除霜-0873");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_qianchushuang_0874()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-前除霜-0874");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qianchushuang_0875()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-前除霜-0875");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//Active
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//Active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_qianchushuang_0876()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-前除霜-0876");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//Active
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//Active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhinengchuwei_0877()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-智能除味-0877");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq("SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhinengchuwei_0878()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-智能除味-0878");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq("SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhinengchuwei_0879()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-智能除味-0879");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//Active
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//Active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhinengchuwei_0880()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-智能除味-0880");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//Active
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//Active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_houkongdiaowugantongfeng_0881()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-后空调无感通风-0881");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_houkongdiaowugantongfeng_0882()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-后空调无感通风-0882");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_houkongdiaowugantongfeng_0883()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-后空调无感通风-0883");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_houkongdiaowugantongfeng_0884()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-后空调无感通风-0884");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziganzao_0885()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自干燥-0885");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziganzao_0886()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自干燥-0886");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq("SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziganzao_0887()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自干燥-0887");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziganzao_0888()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自干燥-0888");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq("SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wenqutongbu_0889()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温区同步-0889");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetSyncStruct.SetSync 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetSyncStruct.Veh_SetSync:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetSyncStruct.Veh_SetSync:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetSyncStruct.SetSync 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wenqutongbu_0890()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温区同步-0890");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetSyncStruct.SetSync 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetSyncStruct.Veh_SetSync:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetSyncStruct.Veh_SetSync:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq("SetSyncStruct.SetSync 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wenqutongbu_0891()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温区同步-0891");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("SetSyncStruct.SetSync 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetSyncStruct.Veh_SetSync:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetSyncStruct.Veh_SetSync:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("SetSyncStruct.SetSync 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_wenqutongbu_0892()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-温区同步-0892");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetSyncStruct.SetSync 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetSyncStruct.Veh_SetSync:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetSyncStruct.Veh_SetSync:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq("SetSyncStruct.SetSync 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0893()
{
  TestDescription("设置前空调风量(步进加) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0893");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:0"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:0//OFF
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0894()
{
  TestDescription("设置前空调风量(步进加) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0894");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:1"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:1//Level 1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0895()
{
  TestDescription("设置前空调风量(步进加) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0895");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:2"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:2//Level 2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0896()
{
  TestDescription("设置前空调风量(步进加) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0896");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:3"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:3//Level 3
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0897()
{
  TestDescription("设置前空调风量(步进加) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0897");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:4"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:4//Level 4
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0898()
{
  TestDescription("设置前空调风量(步进加) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0898");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:5"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:5//Level 5
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0899()
{
  TestDescription("设置前空调风量(步进加) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0899");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:6"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:6//Level 6
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0900()
{
  TestDescription("设置前空调风量(步进加) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0900");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:7"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:7//Level 7
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 8"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 8"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0901()
{
  TestDescription("设置前空调风量(步进加) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0901");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:8"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:8//Level 8
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 9"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 9"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0902()
{
  TestDescription("设置前空调风量(步进加) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0902");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:9"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:9//Level 9
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 10"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 10"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0903()
{
  TestDescription("设置前空调风量(步进加) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0903");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:10"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:10//Level 10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 10"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 10"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0904()
{
  TestDescription("设置前空调风量(目标设置) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0904");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 0&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:0&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:0&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 0&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0905()
{
  TestDescription("设置前空调风量(目标设置) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0905");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0906()
{
  TestDescription("设置前空调风量(目标设置) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0906");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 2"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 2"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0907()
{
  TestDescription("设置前空调风量(目标设置) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0907");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0908()
{
  TestDescription("设置前空调风量(目标设置) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0908");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0909()
{
  TestDescription("设置前空调风量(目标设置) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0909");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0910()
{
  TestDescription("设置前空调风量(目标设置) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0910");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:6&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0911()
{
  TestDescription("设置前空调风量(目标设置) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0911");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:7&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0912()
{
  TestDescription("设置前空调风量(目标设置) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0912");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 8"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:8&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:8&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 8"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0913()
{
  TestDescription("设置前空调风量(目标设置) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0913");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 9"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:9&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:9&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 9"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0914()
{
  TestDescription("设置前空调风量(目标设置) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0914");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 10"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:10&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:10&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 10"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0915()
{
  TestDescription("设置前空调风量(步进减) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0915");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:10"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:10//Level 10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 9&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 9&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0916()
{
  TestDescription("设置前空调风量(步进减) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0916");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:9"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:9//Level 9
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 8&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 8&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0917()
{
  TestDescription("设置前空调风量(步进减) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0917");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:8"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:8//Level 8
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0918()
{
  TestDescription("设置前空调风量(步进减) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0918");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:7"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:7//Level 7
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0919()
{
  TestDescription("设置前空调风量(步进减) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0919");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:6"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:6//Level 6
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0920()
{
  TestDescription("设置前空调风量(步进减) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0920");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:5"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:5//Level 5
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0921()
{
  TestDescription("设置前空调风量(步进减) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0921");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:4"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:4//Level 4
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0922()
{
  TestDescription("设置前空调风量(步进减) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0922");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:3"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:3//Level 3
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 2"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 2"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0923()
{
  TestDescription("设置前空调风量(步进减) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0923");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:2"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:2//Level 2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0924()
{
  TestDescription("设置前空调风量(步进减) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0924");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:1"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:1//Level 1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0925()
{
  TestDescription("设后空调风量(步进加) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0925");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:0"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:0//Level 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0926()
{
  TestDescription("设后空调风量(步进加) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0926");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:1"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:1//Level 1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 2&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 2&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0927()
{
  TestDescription("设后空调风量(步进加) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0927");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:2"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:2//Level 2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0928()
{
  TestDescription("设后空调风量(步进加) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0928");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:3"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:3//Level 3
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0929()
{
  TestDescription("设后空调风量(步进加) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0929");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:4"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:4//Level 4
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0930()
{
  TestDescription("设后空调风量(步进加) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0930");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:5"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:5//Level 5
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0931()
{
  TestDescription("设后空调风量(目标设置) Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0931");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlRrWindSpdRespStruct.Veh_CtrlRrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlRrWindSpdRespStruct.Veh_CtrlRrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlRrWindSpdStruct.Veh_CtrlRrWindSpd:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1&MemoryReq:1"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlRrWindSpdStruct.Veh_CtrlRrWindSpd:5&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1&MemoryReq:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlRrWindSpdRespStruct.Veh_CtrlRrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlRrWindSpdRespStruct.Veh_CtrlRrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0932()
{
  TestDescription("设后空调风量（步进减） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0932");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:5"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:5//Level 5
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 4&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 4&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 4&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 4&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0933()
{
  TestDescription("设后空调风量（步进减） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0933");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:4"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:4//Level 4
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 3&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 3&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0934()
{
  TestDescription("设后空调风量（步进减） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0934");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:3"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:3//Level 3
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 2"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 2"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0935()
{
  TestDescription("设后空调风量（步进减） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0935");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:2"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:2//Level 2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0936()
{
  TestDescription("设后空调风量（步进减） Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0936");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:1"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:1//Level 1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_neixunhuan_0937()
{
  TestDescription("内循环 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-内循环-0937");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetAirIntakeStruct.SetAirIntake 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 1&MemoryReq 0//
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetAirIntakeStruct.Veh_SetAirIntake:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetAirIntakeStruct.Veh_SetAirIntake:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//内循环
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq("SetAirIntakeStruct.SetAirIntake 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 1&MemoryReq 0//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_neixunhuan_0938()
{
  TestDescription("内循环 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-内循环-0938");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetAirIntakeStruct.SetAirIntake 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 1&MemoryReq 1//
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetAirIntakeStruct.Veh_SetAirIntake:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetAirIntakeStruct.Veh_SetAirIntake:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//内循环
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq("SetAirIntakeStruct.SetAirIntake 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 1&MemoryReq 1//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_waixunhuan_0939()
{
  TestDescription("外循环 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-外循环-0939");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetAirIntakeStruct.SetAirIntake 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 2&MemoryReq 0//
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetAirIntakeStruct.Veh_SetAirIntake:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetAirIntakeStruct.Veh_SetAirIntake:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//外循环
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq("SetAirIntakeStruct.SetAirIntake 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 2&MemoryReq 0//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_waixunhuan_0940()
{
  TestDescription("外循环 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-外循环-0940");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetAirIntakeStruct.SetAirIntake 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 2&MemoryReq 1//
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetAirIntakeStruct.Veh_SetAirIntake:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetAirIntakeStruct.Veh_SetAirIntake:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//外循环
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq("SetAirIntakeStruct.SetAirIntake 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 2&MemoryReq 1//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_shezhikongdiaojienengmoshi_0941()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-设置空调节能模式-0941");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq("setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_shezhikongdiaojienengmoshi_0942()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-设置空调节能模式-0942");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq("setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_shezhikongdiaojienengmoshi_0943()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-设置空调节能模式-0943");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq("setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_shezhikongdiaojienengmoshi_0944()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-设置空调节能模式-0944");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq("setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_AQSgongneng_0945()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-AQS功能-0945");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_AQSgongneng_0946()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-AQS功能-0946");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_AQSgongneng_0947()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-AQS功能-0947");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_AQSgongneng_0948()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-AQS功能-0948");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongqijinghuagongneng_0949()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空气净化功能-0949");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongqijinghuagongneng_0950()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空气净化功能-0950");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongqijinghuagongneng_0951()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空气净化功能-0951");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongqijinghuagongneng_0952()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空气净化功能-0952");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaolengnuantongfenggongneng_0953()
{
  TestDescription("打开空调冷暖通风功能 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调冷暖通风功能-0953");
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("60"); // 测试步骤 TC_Sleep 60
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOFFHCVStruct.TurnOnOFFHCV 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 1&MemoryReq 0//CoolingOn
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//CoolingOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq("HighVoltageCtrlStruct.HighVoltageCtrl 2"); // 预期结果 TC_CANTest SOA CheckReq HighVoltageCtrlStruct.HighVoltageCtrl 2 //请求上高压
  gTC_CANTest_SOA_CheckReq("TurnOnOFFHCVStruct.TurnOnOFFHCV 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 1&MemoryReq 0//CoolingOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 traceback2//检查RESPONSE
}

testcase SYS_CDCU_kongdiaolengnuantongfenggongneng_0954()
{
  TestDescription("打开空调冷暖通风功能 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调冷暖通风功能-0954");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOFFHCVStruct.TurnOnOFFHCV 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 2&MemoryReq 1//HeatOn
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//HeatOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOFFHCVStruct.TurnOnOFFHCV 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 2&MemoryReq 1//HeatOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaolengnuantongfenggongneng_0955()
{
  TestDescription("打开空调冷暖通风功能 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调冷暖通风功能-0955");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOFFHCVStruct.TurnOnOFFHCV 3"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 3//VentilateOn
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:3&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//VentilateOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOFFHCVStruct.TurnOnOFFHCV 3"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 3//VentilateOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaolengnuantongfenggongneng_0956()
{
  TestDescription("打开空调冷暖通风功能 Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调冷暖通风功能-0956");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOFFHCVStruct.TurnOnOFFHCV 4"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 4//AutoHCVOn
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:4&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//AutoHCVOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOFFHCVStruct.TurnOnOFFHCV 4"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 4//AutoHCVOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qianhoukongdiaozidongmoshi_0957()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-前后空调自动模式-0957");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qianhoukongdiaozidongmoshi_0958()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-前后空调自动模式-0958");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qianhoukongdiaozidongmoshi_0959()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-前后空调自动模式-0959");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnFrACStruct.TurnOnFrAC 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnFrACStruct.TurnOnFrAC 0 //MemoAC
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.Veh_TurnOnOffACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnFrACStruct.TurnOnFrAC 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnFrACStruct.TurnOnFrAC 0 //MemoAC
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhujiadiandongchufengkoumoshidiaojie_0960()
{
  TestDescription("0x1:Singlewind Power=OFF 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-主驾电动出风口模式调节-0960");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 1&MemoryReq 0 //Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:1&ServiceExecuteFeedbackFlag:2//Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 1&MemoryReq 0 //Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhujiadiandongchufengkoumoshidiaojie_0961()
{
  TestDescription("0x2:Mirrorwind 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-主驾电动出风口模式调节-0961");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 2&MemoryReq 1 //Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 2&MemoryReq 1 //Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhujiadiandongchufengkoumoshidiaojie_0962()
{
  TestDescription("0x3:Freewind 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-主驾电动出风口模式调节-0962");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 3 //Freewind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:3&ServiceExecuteFeedbackFlag:2//Freewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 3 //Freewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhujiadiandongchufengkoumoshidiaojie_0963()
{
  TestDescription("0x4:Avoid 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-主驾电动出风口模式调节-0963");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 4 //Avoid
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:4&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:4&ServiceExecuteFeedbackFlag:2//Avoid
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 4 //Avoid
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhujiadiandongchufengkoumoshidiaojie_0964()
{
  TestDescription("0x5:Intelligent 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-主驾电动出风口模式调节-0964");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 5 //Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:5&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvWindModeStruct.Veh_SetEAVDrvWindMode:5&ServiceExecuteFeedbackFlag:2//Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvWindModeRespStruct.Veh_SetEAVDrvWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvWindModeStruct.SetEAVDrvWindMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvWindModeStruct.SetEAVDrvWindMode 5 //Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_fujiadiandongchufengkoumoshidiaojie_0965()
{
  TestDescription("0x1:Singlewind Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-副驾电动出风口模式调节-0965");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 1&MemoryReq 0 //Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:1&ServiceExecuteFeedbackFlag:2//Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 1&MemoryReq 0 //Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_fujiadiandongchufengkoumoshidiaojie_0966()
{
  TestDescription("0x2:Mirrorwind Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-副驾电动出风口模式调节-0966");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 2&MemoryReq 1 //Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 2&MemoryReq 1 //Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_fujiadiandongchufengkoumoshidiaojie_0967()
{
  TestDescription("0x3:Freewind Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-副驾电动出风口模式调节-0967");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 3 //Freewind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:3&ServiceExecuteFeedbackFlag:2//Freewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 3 //Freewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_fujiadiandongchufengkoumoshidiaojie_0968()
{
  TestDescription("0x4:Avoid Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-副驾电动出风口模式调节-0968");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 4 //Avoid
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:4&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:4&ServiceExecuteFeedbackFlag:2//Avoid
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 4 //Avoid
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_fujiadiandongchufengkoumoshidiaojie_0969()
{
  TestDescription("0x5:Intelligent Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-副驾电动出风口模式调节-0969");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 5 //Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:5&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnWindModeStruct.Veh_SetEAVPsnWindMode:5&ServiceExecuteFeedbackFlag:2//Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnWindModeRespStruct.Veh_SetEAVPsnWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnWindModeStruct.SetEAVPsnWindMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnWindModeStruct.SetEAVPsnWindMode 5 //Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoumoshidiaojiehoupai_zuo_0970()
{
  TestDescription("0x1:Singlewind Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口模式调节(后排-左)-0970");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLWindModeStruct.SetEAVRLWindMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLWindModeStruct.SetEAVRLWindMode 1&MemoryReq 0 //Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLWindModeStruct.Veh_SetEAVRLWindMode:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLWindModeStruct.Veh_SetEAVRLWindMode:1&ServiceExecuteFeedbackFlag:2//0x1:Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLWindModeStruct.SetEAVRLWindMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLWindModeStruct.SetEAVRLWindMode 1&MemoryReq 0 //Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoumoshidiaojiehoupai_zuo_0971()
{
  TestDescription("0x2:Mirrorwind Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口模式调节(后排-左)-0971");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLWindModeStruct.SetEAVRLWindMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLWindModeStruct.SetEAVRLWindMode 2&MemoryReq 1 //Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLWindModeStruct.Veh_SetEAVRLWindMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLWindModeStruct.Veh_SetEAVRLWindMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//0x2:Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLWindModeStruct.SetEAVRLWindMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLWindModeStruct.SetEAVRLWindMode 2&MemoryReq 1 //Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoumoshidiaojiehoupai_zuo_0972()
{
  TestDescription("0x3:Freewind Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口模式调节(后排-左)-0972");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLWindModeStruct.SetEAVRLWindMode 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLWindModeStruct.SetEAVRLWindMode 3&MemoryReq 0 //Freewind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLWindModeStruct.Veh_SetEAVRLWindMode:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLWindModeStruct.Veh_SetEAVRLWindMode:3&ServiceExecuteFeedbackFlag:2//0x3:Freewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLWindModeStruct.SetEAVRLWindMode 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLWindModeStruct.SetEAVRLWindMode 3&MemoryReq 0 //Freewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoumoshidiaojiehoupai_zuo_0973()
{
  TestDescription("0x4:Avoid Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口模式调节(后排-左)-0973");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLWindModeStruct.SetEAVRLWindMode 4&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLWindModeStruct.SetEAVRLWindMode 4&MemoryReq 0 //Avoid
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLWindModeStruct.Veh_SetEAVRLWindMode:4&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLWindModeStruct.Veh_SetEAVRLWindMode:4&ServiceExecuteFeedbackFlag:2//0x4:Avoid
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLWindModeStruct.SetEAVRLWindMode 4&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLWindModeStruct.SetEAVRLWindMode 4&MemoryReq 0 //Avoid
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoumoshidiaojiehoupai_zuo_0974()
{
  TestDescription("0x5:Intelligent Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口模式调节(后排-左)-0974");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRLWindModeStruct.SetEAVRLWindMode 5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLWindModeStruct.SetEAVRLWindMode 5&MemoryReq 0 //Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRLWindModeStruct.Veh_SetEAVRLWindMode:5&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRLWindModeStruct.Veh_SetEAVRLWindMode:5&ServiceExecuteFeedbackFlag:2//0x5:Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRLWindModeRespStruct.Veh_SetEAVRLWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRLWindModeStruct.SetEAVRLWindMode 5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRLWindModeStruct.SetEAVRLWindMode 5&MemoryReq 0 //Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoumoshidiaojiehoupai_you_0975()
{
  TestDescription("0x1:Singlewind Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口模式调节(后排-右)-0975");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRWindModeStruct.SetEAVRRWindMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRWindModeStruct.SetEAVRRWindMode 1&MemoryReq 0 //Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRWindModeStruct.Veh_SetEAVRRWindMode:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRWindModeStruct.Veh_SetEAVRRWindMode:1&ServiceExecuteFeedbackFlag:2//0x1:Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRWindModeStruct.SetEAVRRWindMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRWindModeStruct.SetEAVRRWindMode 1&MemoryReq 0 //Singlewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoumoshidiaojiehoupai_you_0976()
{
  TestDescription("0x2:Mirrorwind Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口模式调节(后排-右)-0976");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRWindModeStruct.SetEAVRRWindMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRWindModeStruct.SetEAVRRWindMode 2&MemoryReq 1 //Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRWindModeStruct.Veh_SetEAVRRWindMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRWindModeStruct.Veh_SetEAVRRWindMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//0x2:Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRWindModeStruct.SetEAVRRWindMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRWindModeStruct.SetEAVRRWindMode 2&MemoryReq 1 //Mirrorwind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoumoshidiaojiehoupai_you_0977()
{
  TestDescription("0x3:Freewind Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口模式调节(后排-右)-0977");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRWindModeStruct.SetEAVRRWindMode 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRWindModeStruct.SetEAVRRWindMode 3&MemoryReq 0 //Freewind
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRWindModeStruct.Veh_SetEAVRRWindMode:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRWindModeStruct.Veh_SetEAVRRWindMode:3&ServiceExecuteFeedbackFlag:2//0x3:Freewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRWindModeStruct.SetEAVRRWindMode 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRWindModeStruct.SetEAVRRWindMode 3&MemoryReq 0 //Freewind
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoumoshidiaojiehoupai_you_0978()
{
  TestDescription("0x4:Avoid Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口模式调节(后排-右)-0978");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRWindModeStruct.SetEAVRRWindMode 4&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRWindModeStruct.SetEAVRRWindMode 4&MemoryReq 0 //Avoid
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRWindModeStruct.Veh_SetEAVRRWindMode:4&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRWindModeStruct.Veh_SetEAVRRWindMode:4&ServiceExecuteFeedbackFlag:2//0x4:Avoid
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRWindModeStruct.SetEAVRRWindMode 4&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRWindModeStruct.SetEAVRRWindMode 4&MemoryReq 0 //Avoid
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_quanchediandongchufengkoumoshidiaojiehoupai_you_0979()
{
  TestDescription("0x5:Intelligent Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-全车电动出风口模式调节(后排-右)-0979");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVRRWindModeStruct.SetEAVRRWindMode 5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRWindModeStruct.SetEAVRRWindMode 5&MemoryReq 0 //Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVRRWindModeStruct.Veh_SetEAVRRWindMode:5&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVRRWindModeStruct.Veh_SetEAVRRWindMode:5&ServiceExecuteFeedbackFlag:2//0x5:Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVRRWindModeRespStruct.Veh_SetEAVRRWindModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVRRWindModeStruct.SetEAVRRWindMode 5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVRRWindModeStruct.SetEAVRRWindMode 5&MemoryReq 0 //Intelligent
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojie_0980()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节-0980");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVSweepWindStruct.SetEAVSweepWind 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 1&MemoryReq 0 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVSweepWindStruct.SetEAVSweepWind 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 1&MemoryReq 0 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojie_0981()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节-0981");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVSweepWindStruct.SetEAVSweepWind 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 1&MemoryReq 1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVSweepWindStruct.SetEAVSweepWind 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 1&MemoryReq 1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojie_0982()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节-0982");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVSweepWindStruct.SetEAVSweepWind 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 2&MemoryReq 0 //ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:2&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVSweepWindStruct.SetEAVSweepWind 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 2&MemoryReq 0 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojie_0983()
{
  TestDescription("IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节-0983");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_NM.I_LDCU_NMReq_CDCU 1"); // 测试步骤 TC_CANTest SET I_LDCU_NM.I_LDCU_NMReq_CDCU 1 //网络唤醒维持帧
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojie_0984()
{
  TestDescription("ON 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节-0984");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVSweepWindStruct.SetEAVSweepWind 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 2&MemoryReq 1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVSweepWindStruct.Veh_SetEAVSweepWind:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVSweepWindRespStruct.Veh_SetEAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVSweepWindStruct.SetEAVSweepWind 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVSweepWindStruct.SetEAVSweepWind 2&MemoryReq 1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojiehoupai_0985()
{
  TestDescription("OFF 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节(后排)-0985");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 0 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 0 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojiehoupai_0986()
{
  TestDescription("OFF 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节(后排)-0986");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojiehoupai_0987()
{
  TestDescription("ON 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节(后排)-0987");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 0 //ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:2&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 0 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojiehoupai_0988()
{
  TestDescription("ON 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节(后排)-0988");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojiehoupai_0989()
{
  TestDescription("ON 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节(后排)-0989");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 0 //ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:2&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 2&MemoryReq 0 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojiehoupai_0990()
{
  TestDescription("OFF 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节(后排)-0990");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouquanchezuoyousaofengmoshidiaojiehoupai_0991()
{
  TestDescription("OFF 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口全车左右扫风模式调节(后排)-0991");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 0 //ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetREAVSweepWindStruct.Veh_SetREAVSweepWind:1&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetREAVSweepWindRespStruct.Veh_SetREAVSweepWindNRC 0
  gTC_CANTest_SOA_CheckReq("SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetREAVSweepWindStruct.SetREAVSweepWind 1&MemoryReq 0 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_0992()
{
  TestDescription("0x1:Position1 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-0992");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:1&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_0993()
{
  TestDescription("0x0:Nocommand 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-0993");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_0994()
{
  TestDescription("0x1:Position1 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-0994");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:1&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_0995()
{
  TestDescription("0x2:Position2 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-0995");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_0996()
{
  TestDescription("0x3:Position3 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-0996");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:3&ServiceExecuteFeedbackFlag:2//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_0997()
{
  TestDescription("0x4:Position4 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-0997");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:4&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:4&ServiceExecuteFeedbackFlag:2//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_0998()
{
  TestDescription("0x5:Position5 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-0998");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:5&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:5&ServiceExecuteFeedbackFlag:2//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_0999()
{
  TestDescription("0x6:Position6 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-0999");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:6&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:6&ServiceExecuteFeedbackFlag:2//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1000()
{
  TestDescription("0x7:Position7 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1000");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:7&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:7&ServiceExecuteFeedbackFlag:2//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1001()
{
  TestDescription("0xD:Open 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1001");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xD&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xD&ServiceExecuteFeedbackFlag:2//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1002()
{
  TestDescription("0xE:OFF 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1002");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xE&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xE&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuoceshuipingweizhidiaojie_1003()
{
  TestDescription("0xF:Error 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧水平位置调节-1003");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xF&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftHorzPosStruct.Veh_SetEAVDrvLeftHorzPos:0xF&ServiceExecuteFeedbackFlag:2//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftHorzPosRespStruct.Veh_SetEAVDrvLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftHorzPosStruct.SetEAVDrvLeftHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1004()
{
  TestDescription("0x1:Position1 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1004");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:1&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1005()
{
  TestDescription("0x0:Nocommand 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1005");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1006()
{
  TestDescription("0x2:Position2 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1006");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1007()
{
  TestDescription("0x3:Position3 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1007");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:3&ServiceExecuteFeedbackFlag:2//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1008()
{
  TestDescription("0x4:Position4 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1008");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:4&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:4&ServiceExecuteFeedbackFlag:2//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1009()
{
  TestDescription("0x5:Position5 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1009");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:5&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:5&ServiceExecuteFeedbackFlag:2//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1010()
{
  TestDescription("0x6:Position6 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1010");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:6&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:6&ServiceExecuteFeedbackFlag:2//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1011()
{
  TestDescription("0x7:Position7 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1011");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:7&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:7&ServiceExecuteFeedbackFlag:2//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1012()
{
  TestDescription("0xD:Open 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1012");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xD&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xD&ServiceExecuteFeedbackFlag:2//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1013()
{
  TestDescription("0xE:OFF 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1013");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xE&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xE&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiazuocechuizhiweizhidiaojie_1014()
{
  TestDescription("0xF:Error 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾左侧垂直位置调节-1014");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xF&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvLeftVertPosStruct.Veh_SetEAVDrvLeftVertPos:0xF&ServiceExecuteFeedbackFlag:2//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvLeftVertPosRespStruct.Veh_SetEAVDrvLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvLeftVertPosStruct.SetEAVDrvLeftVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1015()
{
  TestDescription("0x1:Position1 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1015");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:1&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1016()
{
  TestDescription("0x0:Nocommand 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1016");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1017()
{
  TestDescription("0x2:Position2 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1017");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1018()
{
  TestDescription("0x3:Position3 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1018");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:3&ServiceExecuteFeedbackFlag:2//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1019()
{
  TestDescription("0x4:Position4 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1019");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:4&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:4&ServiceExecuteFeedbackFlag:2//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1020()
{
  TestDescription("0x5:Position5 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1020");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:5&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:5&ServiceExecuteFeedbackFlag:2//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1021()
{
  TestDescription("0x6:Position6 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1021");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:6&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:6&ServiceExecuteFeedbackFlag:2//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1022()
{
  TestDescription("0x7:Position7 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1022");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:7&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:7&ServiceExecuteFeedbackFlag:2//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1023()
{
  TestDescription("0xD:Open 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1023");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xD&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xD&ServiceExecuteFeedbackFlag:2//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1024()
{
  TestDescription("0xE:OFF 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1024");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xE&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xE&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayouceshuipingweizhidiaojie_1025()
{
  TestDescription("0xF:Error 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧水平位置调节-1025");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xF&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightHorzPosStruct.Veh_SetEAVDrvRightHorzPos:0xF&ServiceExecuteFeedbackFlag:2//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightHorzPosRespStruct.Veh_SetEAVDrvRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightHorzPosStruct.SetEAVDrvRightHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1026()
{
  TestDescription("0x1:Position1 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1026");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:1&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1027()
{
  TestDescription("0x0:Nocommand 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1027");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1028()
{
  TestDescription("0x2:Position2 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1028");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1029()
{
  TestDescription("0x3:Position3 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1029");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:3&ServiceExecuteFeedbackFlag:2//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1030()
{
  TestDescription("0x4:Position4 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1030");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:4&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:4&ServiceExecuteFeedbackFlag:2//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1031()
{
  TestDescription("0x5:Position5 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1031");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:5&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:5&ServiceExecuteFeedbackFlag:2//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1032()
{
  TestDescription("0x6:Position6 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1032");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:6&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:6&ServiceExecuteFeedbackFlag:2//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1033()
{
  TestDescription("0x7:Position7 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1033");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:7&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:7&ServiceExecuteFeedbackFlag:2//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1034()
{
  TestDescription("0xD:Open 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1034");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xD&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xD&ServiceExecuteFeedbackFlag:2//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1035()
{
  TestDescription("0xE:OFF 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1035");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xE&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xE&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkouzhujiayoucechuizhiweizhidiaojie_1036()
{
  TestDescription("0xF:Error 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口主驾右侧垂直位置调节-1036");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xF&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVDrvRightVertPosStruct.Veh_SetEAVDrvRightVertPos:0xF&ServiceExecuteFeedbackFlag:2//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVDrvRightVertPosRespStruct.Veh_SetEAVDrvRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVDrvRightVertPosStruct.SetEAVDrvRightVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1037()
{
  TestDescription("0x1:Position1 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1037");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:1&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1038()
{
  TestDescription("0x0:Nocommand 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1038");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1039()
{
  TestDescription("0x2:Position2 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1039");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1040()
{
  TestDescription("0x3:Position3 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1040");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:3&ServiceExecuteFeedbackFlag:2//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1041()
{
  TestDescription("0x4:Position4 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1041");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:4&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:4&ServiceExecuteFeedbackFlag:2//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1042()
{
  TestDescription("0x5:Position5 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1042");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:5&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:5&ServiceExecuteFeedbackFlag:2//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1043()
{
  TestDescription("0x6:Position6 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1043");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:6&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:6&ServiceExecuteFeedbackFlag:2//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1044()
{
  TestDescription("0x7:Position7 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1044");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:7&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:7&ServiceExecuteFeedbackFlag:2//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1045()
{
  TestDescription("0xD:Open 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1045");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xD&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xD&ServiceExecuteFeedbackFlag:2//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1046()
{
  TestDescription("0xE:OFF 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1046");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xE&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xE&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuoceshuipingweizhidiaojie_1047()
{
  TestDescription("0xF:Error 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧水平位置调节-1047");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xF&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftHorzPosStruct.Veh_SetEAVPsnLeftHorzPos:0xF&ServiceExecuteFeedbackFlag:2//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftHorzPosRespStruct.Veh_SetEAVPsnLeftHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftHorzPosStruct.SetEAVPsnLeftHorzPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1048()
{
  TestDescription("0x1:Position1 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1048");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:1&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1049()
{
  TestDescription("0x0:Nocommand 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1049");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1050()
{
  TestDescription("0x2:Position2 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1050");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Position2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1051()
{
  TestDescription("0x3:Position3 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1051");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:3&ServiceExecuteFeedbackFlag:2//Position3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 3"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 3 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1052()
{
  TestDescription("0x4:Position4 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1052");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:4&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:4&ServiceExecuteFeedbackFlag:2//Position4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 4"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 4 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1053()
{
  TestDescription("0x5:Position5 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1053");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:5&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:5&ServiceExecuteFeedbackFlag:2//Position5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 5"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 5 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1054()
{
  TestDescription("0x6:Position6 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1054");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:6&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:6&ServiceExecuteFeedbackFlag:2//Position6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 6"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 6 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1055()
{
  TestDescription("0x7:Position7 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1055");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:7&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:7&ServiceExecuteFeedbackFlag:2//Position7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 7"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 7 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1056()
{
  TestDescription("0xD:Open 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1056");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xD&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xD&ServiceExecuteFeedbackFlag:2//Open
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xD"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xD //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1057()
{
  TestDescription("0xE:OFF 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1057");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xE&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xE&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiazuocechuizhiweizhidiaojie_1058()
{
  TestDescription("0xF:Error 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾左侧垂直位置调节-1058");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xF&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnLeftVertPosStruct.Veh_SetEAVPsnLeftVertPos:0xF&ServiceExecuteFeedbackFlag:2//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnLeftVertPosRespStruct.Veh_SetEAVPsnLeftVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnLeftVertPosStruct.SetEAVPsnLeftVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1059()
{
  TestDescription("0x1:Position1 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1059");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:1&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 1&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1060()
{
  TestDescription("0x0:Nocommand 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1060");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightHorzPosStruct.Veh_SetEAVPsnRightHorzPos:0&ServiceExecuteFeedbackFlag:2//Position1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 0&MemoryReq 0 //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayouceshuipingweizhidiaojie_1061()
{
  TestDescription("0x2:Position2 非远控域");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧水平位置调节-1061");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightHorzPosRespStruct.Veh_SetEAVPsnRightHorzPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightHorzPosStruct.SetEAVPsnRightHorzPos 2&MemoryReq 1 //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
