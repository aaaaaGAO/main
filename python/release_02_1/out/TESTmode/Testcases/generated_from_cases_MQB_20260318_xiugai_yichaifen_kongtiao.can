/*@!Encoding: 936*/

includes
{
}

variables
{
}

testcase SYS_CDCU_wendudiaojieIGON_0001()
{
  TestDescription("主驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0001");
  g_EM_Equipment_Swc_TC_PW("ON"); // 测试步骤 TC_PW ON
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 1
  gTC_CANTest_SOA_Set8001Delay("0"); // 测试步骤 TC_CANTest SOA Set8001Delay 0
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:20"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:20//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_SubPeriod("SOAEngineInterState 1"); // 测试步骤 TC_CANTest SOA SubPeriod SOAEngineInterState 1
  g_EM_SOAClient_Swc_SOA_SubPeriod("Veh_HVACService_ErrGrp 1"); // 测试步骤 TC_CANTest SOA SubPeriod Veh_HVACService_ErrGrp 1
  g_EM_SOAClient_Swc_SOA_SubPeriod("Veh_HVACPush 1"); // 测试步骤 TC_CANTest SOA SubPeriod Veh_HVACPush 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 20.5&MemoryReq 0&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 20.5&MemoryReq 0&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 20.5&MemoryReq 0&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 20.5&MemoryReq 0&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0002()
{
  TestDescription("主驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0002");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0003()
{
  TestDescription("主驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0003");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 25&MemoryReq 0&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 25&MemoryReq 0&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 25&MemoryReq 0&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 25&MemoryReq 0&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0004()
{
  TestDescription("主驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0004");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 21&MemoryReq 1&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 21&MemoryReq 1&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetDrvTempStruct.Veh_SetDrvTemp:21&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetDrvTempStruct.Veh_SetDrvTemp:21&MemoryReq:1&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.Veh_SetDrvTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 21&MemoryReq 1&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 21&MemoryReq 1&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0005()
{
  TestDescription("主驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0005");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:22"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:22//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 23&MemoryReq 0&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 23&MemoryReq 0&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:2&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 23&MemoryReq 0&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 23&MemoryReq 0&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0006()
{
  TestDescription("主驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0006");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.Veh_DriverTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 32&MemoryReq 1&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0007()
{
  TestDescription("主驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0007");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 31.5&MemoryReq 0&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 31.5&MemoryReq 0&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempDownStruct.Veh_DriverTempDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempDownStruct.Veh_DriverTempDown:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 31.5&MemoryReq 0&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 31.5&MemoryReq 0&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0008()
{
  TestDescription("主驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0008");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempDownStruct.Veh_DriverTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempDownStruct.Veh_DriverTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0009()
{
  TestDescription("主驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0009");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:25"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:25//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 24&MemoryReq 0&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 24&MemoryReq 0&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempDownStruct.Veh_DriverTempDown:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempDownStruct.Veh_DriverTempDown:2&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 24&MemoryReq 0&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 24&MemoryReq 0&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0010()
{
  TestDescription("主驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0010");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.DriverTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.DriverTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempDownStruct.Veh_DriverTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempDownStruct.Veh_DriverTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempDownRespStruct.Veh_DriverTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 0"); // 预期结果 TC_CANTest SOA CheckReq SetDrvTempStruct.SetDrvTemp 18&MemoryReq 1&Type 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0011()
{
  TestDescription("副驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0011");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:21"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:21//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 21.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 21.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempUpStruct.Veh_PsnTempUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempUpStruct.Veh_PsnTempUp:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 21.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 21.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0012()
{
  TestDescription("副驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0012");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempUpStruct.Veh_PsnTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempUpStruct.Veh_PsnTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0013()
{
  TestDescription("副驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0013");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetPsnTempStruct.Veh_SetPsnTemp:18&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetPsnTempStruct.Veh_SetPsnTemp:18&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0014()
{
  TestDescription("副驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0014");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetPsnTempStruct.Veh_SetPsnTemp:18&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetPsnTempStruct.Veh_SetPsnTemp:18&MemoryReq:1&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetPsnTempRespStruct.Veh_SetPsnTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0015()
{
  TestDescription("副驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0015");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:19"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:19//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 20&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 20&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempUpStruct.Veh_PsnTempUp:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempUpStruct.Veh_PsnTempUp:2&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 20&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 20&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0016()
{
  TestDescription("副驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0016");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempUpStruct.Veh_PsnTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempUpStruct.Veh_PsnTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempUpRespStruct.Veh_PsnTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0017()
{
  TestDescription("副驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0017");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:19"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:19//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 18.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempDownStruct.Veh_PsnTempDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempDownStruct.Veh_PsnTempDown:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 18.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0018()
{
  TestDescription("副驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0018");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempDownStruct.Veh_PsnTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempDownStruct.Veh_PsnTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0019()
{
  TestDescription("副驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0019");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 31&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 31&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempDownStruct.Veh_PsnTempDown:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempDownStruct.Veh_PsnTempDown:2&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 31&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 31&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0020()
{
  TestDescription("副驾空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0020");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.PsnTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.PsnTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_PsnTempDownStruct.Veh_PsnTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_PsnTempDownStruct.Veh_PsnTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_PsnTempDownRespStruct.Veh_PsnTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetPsnTempStruct.SetPsnTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0021()
{
  TestDescription("二排左空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0021");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:19"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:19//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 19.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 19.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempUpStruct.Veh_RLTempUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempUpStruct.Veh_RLTempUp:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 19.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 19.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0022()
{
  TestDescription("二排左空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0022");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempUpStruct.Veh_RLTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempUpStruct.Veh_RLTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0023()
{
  TestDescription("二排左空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0023");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 30&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 30&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRLTempStruct.Veh_SetRLTemp:30&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRLTempStruct.Veh_SetRLTemp:30&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 30&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 30&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0024()
{
  TestDescription("二排左空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0024");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 30&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 30&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRLTempStruct.Veh_SetRLTemp:30&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRLTempStruct.Veh_SetRLTemp:30&MemoryReq:1&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRLTempRespStruct.Veh_SetRLTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 30&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 30&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0025()
{
  TestDescription("二排左空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0025");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 19&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 19&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempUpStruct.Veh_RLTempUp:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempUpStruct.Veh_RLTempUp:2&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 19&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 19&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0026()
{
  TestDescription("二排左空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0026");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempUpStruct.Veh_RLTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempUpStruct.Veh_RLTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempUpRespStruct.Veh_RLTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0027()
{
  TestDescription("二排左空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0027");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 31.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 31.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempDownStruct.Veh_RLTempDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempDownStruct.Veh_RLTempDown:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 31.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 31.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0028()
{
  TestDescription("二排左空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0028");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempDownStruct.Veh_RLTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempDownStruct.Veh_RLTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0029()
{
  TestDescription("二排左空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0029");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:19"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:19//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempDownStruct.Veh_RLTempDown:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempDownStruct.Veh_RLTempDown:2&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0030()
{
  TestDescription("二排左空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0030");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RLTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RLTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRLTempStruct.SetRLTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RLTempDownStruct.Veh_RLTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RLTempDownStruct.Veh_RLTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RLTempDownRespStruct.Veh_RLTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRLTempStruct.SetRLTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRLTempStruct.SetRLTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0031()
{
  TestDescription("二排右空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0031");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:25.5"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:25.5//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 26&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 26&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempUpStruct.Veh_RRTempUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempUpStruct.Veh_RRTempUp:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 26&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 26&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0032()
{
  TestDescription("二排右空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0032");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempUpStruct.Veh_RRTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempUpStruct.Veh_RRTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0033()
{
  TestDescription("二排右空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0033");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 27&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRRTempStruct.Veh_SetRRTemp:27&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRRTempStruct.Veh_SetRRTemp:27&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 27&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0034()
{
  TestDescription("二排右空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0034");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 27&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRRTempStruct.Veh_SetRRTemp:27&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRRTempStruct.Veh_SetRRTemp:27&MemoryReq:1&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRRTempRespStruct.Veh_SetRRTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 27&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0035()
{
  TestDescription("二排右空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0035");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:23"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:23//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 24&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 24&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempUpStruct.Veh_RRTempUp:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempUpStruct.Veh_RRTempUp:2&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 24&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 24&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0036()
{
  TestDescription("二排右空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0036");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempUpStruct.Veh_RRTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempUpStruct.Veh_RRTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempUpRespStruct.Veh_RRTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0037()
{
  TestDescription("二排右空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0037");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:27.5"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:27.5//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 27&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempDownStruct.Veh_RRTempDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempDownStruct.Veh_RRTempDown:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 27&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 27&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0038()
{
  TestDescription("二排右空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0038");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempDownStruct.Veh_RRTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempDownStruct.Veh_RRTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0039()
{
  TestDescription("二排右空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0039");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:27.5"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:27.5//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 26.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 26.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempDownStruct.Veh_RRTempDown:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempDownStruct.Veh_RRTempDown:2&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 26.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 26.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0040()
{
  TestDescription("二排右空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0040");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.RRTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.RRTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRRTempStruct.SetRRTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RRTempDownStruct.Veh_RRTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RRTempDownStruct.Veh_RRTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RRTempDownRespStruct.Veh_RRTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("SetRRTempStruct.SetRRTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRRTempStruct.SetRRTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0041()
{
  TestDescription("三排空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0041");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:29"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:29//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 29.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 29.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 29.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 29.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0042()
{
  TestDescription("三排空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0042");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0043()
{
  TestDescription("三排空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0043");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_Set3rdRowTempStruct.Veh_Set3rdRowTemp:18&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_Set3rdRowTempStruct.Veh_Set3rdRowTemp:18&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0044()
{
  TestDescription("三排空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0044");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_Set3rdRowTempStruct.Veh_Set3rdRowTemp:18&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_Set3rdRowTempStruct.Veh_Set3rdRowTemp:18&MemoryReq:1&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0"); // 预期结果 TC_CANTest SOA check Veh_Set3rdRowTempRespStruct.Veh_Set3rdRowTempNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0045()
{
  TestDescription("三排空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0045");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 19&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 19&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:2&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 19&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 19&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0046()
{
  TestDescription("三排空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0046");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:32"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:32//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempUpStruct.Veh_3rdRowTempUp:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempUpRespStruct.Veh_3rdRowTempUpNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 32&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0047()
{
  TestDescription("三排空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0047");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:28"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:28//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 27.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 27.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 27.5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 27.5&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0048()
{
  TestDescription("三排空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0048");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0049()
{
  TestDescription("三排空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0049");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:22"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:22//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 21&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 21&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:2&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 21&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 21&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wendudiaojieIGON_0050()
{
  TestDescription("三排空调温度调节 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温度调节IGON-0050");
  gTC_CANTest_SOA_SetSever("TempSelectStStruct.ThirdRowTempSelectSt:18"); // 测试步骤 TC_CANTest SOA SetServer TempSelectStStruct.ThirdRowTempSelectSt:18//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_3rdRowTempDownStruct.Veh_3rdRowTempDown:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2 //1步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_3rdRowTempDownRespStruct.Veh_3rdRowTempDownNRC 0
  gTC_CANTest_SOA_CheckReq("Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq Set3rdRowTempStruct.Set3rdRowTemp 18&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_jisujiangwen_0051()
{
  TestDescription("急速降温 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-急速降温-0051");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_jisujiangwen_0052()
{
  TestDescription("急速降温联动 Power=ON Level 1");
  teststep("warning","原始用例id为SYS-CDCU-急速降温-0052");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2
  g_CAN_Bus_Swc_Set("I_LDCU_SeatInfo.I_LDCU_DrvSeatVentilationSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_SeatInfo.I_LDCU_DrvSeatVentilationSt 1//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo.I_RDCU_PsngrSeatVentilationSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo.I_RDCU_PsngrSeatVentilationSt 1//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_LDCU_SeatSysSts.I_LDCU_SecRowLtSeatVentilationSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_SeatSysSts.I_LDCU_SecRowLtSeatVentilationSt 1//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo2.I_RDCU_SecRowRtSeatVentilationSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo2.I_RDCU_SecRowRtSeatVentilationSt 1//设置联动之前的状态
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd 3,I_CDCU_PsngrSeatVentilationCmd 3,I_SecRowLtSeatVentilationCmd 3,I_SecRowRtSeatVentilationCmd 3"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd 3,I_CDCU_PsngrSeatVentilationCmd 3,I_SecRowLtSeatVentilationCmd 3,I_SecRowRtSeatVentilationCmd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxCoolingSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxCoolingSt:1//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd,I_CDCU_PsngrSeatVentilationCmd,I_SecRowLtSeatVentilationCmd,I_SecRowRtSeatVentilationCmd 3:0,3:0,3:0,3:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd,I_CDCU_PsngrSeatVentilationCmd,I_SecRowLtSeatVentilationCmd,I_SecRowRtSeatVentilationCmd 3:0,3:0,3:0,3:0 3;50;50
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd 1,I_CDCU_PsngrSeatVentilationCmd 1,I_SecRowLtSeatVentilationCmd 1,I_SecRowRtSeatVentilationCmd 1"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd 1,I_CDCU_PsngrSeatVentilationCmd 1,I_SecRowLtSeatVentilationCmd 1,I_SecRowRtSeatVentilationCmd 1
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxCoolingSt:0"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxCoolingSt:0//关闭
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd,I_CDCU_PsngrSeatVentilationCmd,I_SecRowLtSeatVentilationCmd,I_SecRowRtSeatVentilationCmd 1:0,1:0,1:0,1:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd,I_CDCU_PsngrSeatVentilationCmd,I_SecRowLtSeatVentilationCmd,I_SecRowRtSeatVentilationCmd 1:0,1:0,1:0,1:0 3;50;50
}

testcase SYS_CDCU_jisujiangwen_0053()
{
  TestDescription("急速降温联动 Power=ON Level 2");
  teststep("warning","原始用例id为SYS-CDCU-急速降温-0053");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2
  g_CAN_Bus_Swc_Set("I_LDCU_SeatInfo.I_LDCU_DrvSeatVentilationSt 2"); // 测试步骤 TC_CANTest SET I_LDCU_SeatInfo.I_LDCU_DrvSeatVentilationSt 2//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo.I_RDCU_PsngrSeatVentilationSt 2"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo.I_RDCU_PsngrSeatVentilationSt 2//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_LDCU_SeatSysSts.I_LDCU_SecRowLtSeatVentilationSt 2"); // 测试步骤 TC_CANTest SET I_LDCU_SeatSysSts.I_LDCU_SecRowLtSeatVentilationSt 2//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo2.I_RDCU_SecRowRtSeatVentilationSt 2"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo2.I_RDCU_SecRowRtSeatVentilationSt 2//设置联动之前的状态
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd 3,I_CDCU_PsngrSeatVentilationCmd 3,I_SecRowLtSeatVentilationCmd 3,I_SecRowRtSeatVentilationCmd 3"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd 3,I_CDCU_PsngrSeatVentilationCmd 3,I_SecRowLtSeatVentilationCmd 3,I_SecRowRtSeatVentilationCmd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxCoolingSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxCoolingSt:1//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd,I_CDCU_PsngrSeatVentilationCmd,I_SecRowLtSeatVentilationCmd,I_SecRowRtSeatVentilationCmd 3:0,3:0,3:0,3:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd,I_CDCU_PsngrSeatVentilationCmd,I_SecRowLtSeatVentilationCmd,I_SecRowRtSeatVentilationCmd 3:0,3:0,3:0,3:0 3;50;50
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd 2,I_CDCU_PsngrSeatVentilationCmd 2,I_SecRowLtSeatVentilationCmd 2,I_SecRowRtSeatVentilationCmd 2"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd 2,I_CDCU_PsngrSeatVentilationCmd 2,I_SecRowLtSeatVentilationCmd 2,I_SecRowRtSeatVentilationCmd 2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxCoolingSt:0"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxCoolingSt:0//关闭
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd,I_CDCU_PsngrSeatVentilationCmd,I_SecRowLtSeatVentilationCmd,I_SecRowRtSeatVentilationCmd 2:0,2:0,2:0,2:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd,I_CDCU_PsngrSeatVentilationCmd,I_SecRowLtSeatVentilationCmd,I_SecRowRtSeatVentilationCmd 2:0,2:0,2:0,2:0 3;50;50
}

testcase SYS_CDCU_jisujiangwen_0054()
{
  TestDescription("急速降温联动 Power=ON OFF");
  teststep("warning","原始用例id为SYS-CDCU-急速降温-0054");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2
  g_CAN_Bus_Swc_Set("I_LDCU_SeatInfo.I_LDCU_DrvSeatVentilationSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_SeatInfo.I_LDCU_DrvSeatVentilationSt 0//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo.I_RDCU_PsngrSeatVentilationSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo.I_RDCU_PsngrSeatVentilationSt 0//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_LDCU_SeatSysSts.I_LDCU_SecRowLtSeatVentilationSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_SeatSysSts.I_LDCU_SecRowLtSeatVentilationSt 0//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo2.I_RDCU_SecRowRtSeatVentilationSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo2.I_RDCU_SecRowRtSeatVentilationSt 0//设置联动之前的状态
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd 3,I_CDCU_PsngrSeatVentilationCmd 3,I_SecRowLtSeatVentilationCmd 3,I_SecRowRtSeatVentilationCmd 3"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd 3,I_CDCU_PsngrSeatVentilationCmd 3,I_SecRowLtSeatVentilationCmd 3,I_SecRowRtSeatVentilationCmd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.Veh_TurnOnOffMaxCoolingNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxCoolingStruct.TurnOnOffMaxCooling 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxCoolingSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxCoolingSt:1//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd,I_CDCU_PsngrSeatVentilationCmd,I_SecRowLtSeatVentilationCmd,I_SecRowRtSeatVentilationCmd 3:0,3:0,3:0,3:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd,I_CDCU_PsngrSeatVentilationCmd,I_SecRowLtSeatVentilationCmd,I_SecRowRtSeatVentilationCmd 3:0,3:0,3:0,3:0 3;50;50
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd 0,I_CDCU_PsngrSeatVentilationCmd 0,I_SecRowLtSeatVentilationCmd 0,I_SecRowRtSeatVentilationCmd 0"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd 0,I_CDCU_PsngrSeatVentilationCmd 0,I_SecRowLtSeatVentilationCmd 0,I_SecRowRtSeatVentilationCmd 0
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxCoolingSt:0"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxCoolingSt:0//关闭
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd,I_CDCU_PsngrSeatVentilationCmd,I_SecRowLtSeatVentilationCmd,I_SecRowRtSeatVentilationCmd 4:0,4:0,4:0,4:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_SeatCtrl.I_CDCU_DrvSeatVentilationCmd,I_CDCU_PsngrSeatVentilationCmd,I_SecRowLtSeatVentilationCmd,I_SecRowRtSeatVentilationCmd 4:0,4:0,4:0,4:0 3;50;50
}

testcase SYS_CDCU_jisushengwen_0055()
{
  TestDescription("急速升温 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-急速升温-0055");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_jisushengwen_0056()
{
  TestDescription("急速升温联动座椅加热 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-急速升温-0056");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2
  g_CAN_Bus_Swc_Set("I_LDCU_SeatInfo.I_LDCU_DrvSeatHeatSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_SeatInfo.I_LDCU_DrvSeatHeatSt 1//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo.I_RDCU_PsngrSeatHeatSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo.I_RDCU_PsngrSeatHeatSt 1//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_LDCU_SeatInfo.I_LDCU_SecRowLtSeatHeatSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_SeatInfo.I_LDCU_SecRowLtSeatHeatSt 1//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo.I_RDCU_SecRowRtSeatHeatSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo.I_RDCU_SecRowRtSeatHeatSt 1//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt2.I_LDCU_SWSHeatSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt2.I_LDCU_SWSHeatSt 1//设置联动之前的状态
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd 3,I_CDCU_PsngrSeatHeatCmd 3,I_CDCU_SecRowLtSeatHeatCmd 3,I_CDCU_SecRowRtSeatHeatCmd 3"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd 3,I_CDCU_PsngrSeatHeatCmd 3,I_CDCU_SecRowLtSeatHeatCmd 3,I_CDCU_SecRowRtSeatHeatCmd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2 //ON 极速升温控制
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxWarmingSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxWarmingSt:1//
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd,I_CDCU_PsngrSeatHeatCmd,I_CDCU_SecRowLtSeatHeatCmd,I_CDCU_SecRowRtSeatHeatCmd 3:0,3:0,3:0,3:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd,I_CDCU_PsngrSeatHeatCmd,I_CDCU_SecRowLtSeatHeatCmd,I_CDCU_SecRowRtSeatHeatCmd 3:0,3:0,3:0,3:0 3;50;50
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd 1,I_CDCU_PsngrSeatHeatCmd 1,I_CDCU_SecRowLtSeatHeatCmd 1,I_CDCU_SecRowRtSeatHeatCmd 1"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd 1,I_CDCU_PsngrSeatHeatCmd 1,I_CDCU_SecRowLtSeatHeatCmd 1,I_CDCU_SecRowRtSeatHeatCmd 1
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxWarmingSt:0"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxWarmingSt:0//
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd,I_CDCU_PsngrSeatHeatCmd,I_CDCU_SecRowLtSeatHeatCmd,I_CDCU_SecRowRtSeatHeatCmd 1:0,1:0,1:0,1:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd,I_CDCU_PsngrSeatHeatCmd,I_CDCU_SecRowLtSeatHeatCmd,I_CDCU_SecRowRtSeatHeatCmd 1:0,1:0,1:0,1:0 3;50;50
}

testcase SYS_CDCU_jisushengwen_0057()
{
  TestDescription("急速升温联动方向盘加热 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-急速升温-0057");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2
  g_CAN_Bus_Swc_Set("I_LDCU_SeatInfo.I_LDCU_DrvSeatHeatSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_SeatInfo.I_LDCU_DrvSeatHeatSt 1//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo.I_RDCU_PsngrSeatHeatSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo.I_RDCU_PsngrSeatHeatSt 1//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_LDCU_SeatInfo.I_LDCU_SecRowLtSeatHeatSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_SeatInfo.I_LDCU_SecRowLtSeatHeatSt 1//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo.I_RDCU_SecRowRtSeatHeatSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo.I_RDCU_SecRowRtSeatHeatSt 1//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt2.I_LDCU_SWSHeatSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt2.I_LDCU_SWSHeatSt 1//设置联动之前的状态
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 3"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxWarmingSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxWarmingSt:1//
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 3:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 3:0 3;50;50
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 1"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 1
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxWarmingSt:0"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxWarmingSt:0//
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 1:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 1:0 3;50;50
}

testcase SYS_CDCU_jisushengwen_0058()
{
  TestDescription("急速升温联动座椅加热 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-急速升温-0058");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2
  g_CAN_Bus_Swc_Set("I_LDCU_SeatInfo.I_LDCU_DrvSeatHeatSt 2"); // 测试步骤 TC_CANTest SET I_LDCU_SeatInfo.I_LDCU_DrvSeatHeatSt 2//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo.I_RDCU_PsngrSeatHeatSt 2"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo.I_RDCU_PsngrSeatHeatSt 2//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_LDCU_SeatInfo.I_LDCU_SecRowLtSeatHeatSt 2"); // 测试步骤 TC_CANTest SET I_LDCU_SeatInfo.I_LDCU_SecRowLtSeatHeatSt 2//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo.I_RDCU_SecRowRtSeatHeatSt 2"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo.I_RDCU_SecRowRtSeatHeatSt 2//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt2.I_LDCU_SWSHeatSt 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt2.I_LDCU_SWSHeatSt 2//设置联动之前的状态
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd 3,I_CDCU_PsngrSeatHeatCmd 3,I_CDCU_SecRowLtSeatHeatCmd 3,I_CDCU_SecRowRtSeatHeatCmd 3"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd 3,I_CDCU_PsngrSeatHeatCmd 3,I_CDCU_SecRowLtSeatHeatCmd 3,I_CDCU_SecRowRtSeatHeatCmd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2 //ON 极速升温控制
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxWarmingSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxWarmingSt:1//
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd,I_CDCU_PsngrSeatHeatCmd,I_CDCU_SecRowLtSeatHeatCmd,I_CDCU_SecRowRtSeatHeatCmd 3:0,3:0,3:0,3:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd,I_CDCU_PsngrSeatHeatCmd,I_CDCU_SecRowLtSeatHeatCmd,I_CDCU_SecRowRtSeatHeatCmd 3:0,3:0,3:0,3:0 3;50;50
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd 2,I_CDCU_PsngrSeatHeatCmd 2,I_CDCU_SecRowLtSeatHeatCmd 2,I_CDCU_SecRowRtSeatHeatCmd 2"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd 2,I_CDCU_PsngrSeatHeatCmd 2,I_CDCU_SecRowLtSeatHeatCmd 2,I_CDCU_SecRowRtSeatHeatCmd 2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxWarmingSt:0"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxWarmingSt:0//
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd,I_CDCU_PsngrSeatHeatCmd,I_CDCU_SecRowLtSeatHeatCmd,I_CDCU_SecRowRtSeatHeatCmd 2:0,2:0,2:0,2:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd,I_CDCU_PsngrSeatHeatCmd,I_CDCU_SecRowLtSeatHeatCmd,I_CDCU_SecRowRtSeatHeatCmd 2:0,2:0,2:0,2:0 3;50;50
}

testcase SYS_CDCU_jisushengwen_0059()
{
  TestDescription("急速升温联动方向盘加热 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-急速升温-0059");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2
  g_CAN_Bus_Swc_Set("I_LDCU_SeatInfo.I_LDCU_DrvSeatHeatSt 2"); // 测试步骤 TC_CANTest SET I_LDCU_SeatInfo.I_LDCU_DrvSeatHeatSt 2//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo.I_RDCU_PsngrSeatHeatSt 2"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo.I_RDCU_PsngrSeatHeatSt 2//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_LDCU_SeatInfo.I_LDCU_SecRowLtSeatHeatSt 2"); // 测试步骤 TC_CANTest SET I_LDCU_SeatInfo.I_LDCU_SecRowLtSeatHeatSt 2//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo.I_RDCU_SecRowRtSeatHeatSt 2"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo.I_RDCU_SecRowRtSeatHeatSt 2//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt2.I_LDCU_SWSHeatSt 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt2.I_LDCU_SWSHeatSt 2//设置联动之前的状态
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 3"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxWarmingSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxWarmingSt:1//
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 3:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 3:0 3;50;50
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 2"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxWarmingSt:0"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxWarmingSt:0//
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 2:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 2:0 3;50;50
}

testcase SYS_CDCU_jisushengwen_0060()
{
  TestDescription("急速升温联动座椅加热 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-急速升温-0060");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2
  g_CAN_Bus_Swc_Set("I_LDCU_SeatInfo.I_LDCU_DrvSeatHeatSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_SeatInfo.I_LDCU_DrvSeatHeatSt 0//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo.I_RDCU_PsngrSeatHeatSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo.I_RDCU_PsngrSeatHeatSt 0//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_LDCU_SeatInfo.I_LDCU_SecRowLtSeatHeatSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_SeatInfo.I_LDCU_SecRowLtSeatHeatSt 0//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo.I_RDCU_SecRowRtSeatHeatSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo.I_RDCU_SecRowRtSeatHeatSt 0//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt2.I_LDCU_SWSHeatSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt2.I_LDCU_SWSHeatSt 0//设置联动之前的状态
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd 3,I_CDCU_PsngrSeatHeatCmd 3,I_CDCU_SecRowLtSeatHeatCmd 3,I_CDCU_SecRowRtSeatHeatCmd 3"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd 3,I_CDCU_PsngrSeatHeatCmd 3,I_CDCU_SecRowLtSeatHeatCmd 3,I_CDCU_SecRowRtSeatHeatCmd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2 //ON 极速升温控制
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxWarmingSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxWarmingSt:1//
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd,I_CDCU_PsngrSeatHeatCmd,I_CDCU_SecRowLtSeatHeatCmd,I_CDCU_SecRowRtSeatHeatCmd 3:0,3:0,3:0,3:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd,I_CDCU_PsngrSeatHeatCmd,I_CDCU_SecRowLtSeatHeatCmd,I_CDCU_SecRowRtSeatHeatCmd 3:0,3:0,3:0,3:0 3;50;50
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd 4,I_CDCU_PsngrSeatHeatCmd 4,I_CDCU_SecRowLtSeatHeatCmd 4,I_CDCU_SecRowRtSeatHeatCmd 4"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd 4,I_CDCU_PsngrSeatHeatCmd 4,I_CDCU_SecRowLtSeatHeatCmd 4,I_CDCU_SecRowRtSeatHeatCmd 4
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxWarmingSt:0"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxWarmingSt:0//
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd,I_CDCU_PsngrSeatHeatCmd,I_CDCU_SecRowLtSeatHeatCmd,I_CDCU_SecRowRtSeatHeatCmd 4:0,4:0,4:0,4:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_SeatCtrl.I_CDCU_DrvSeatHeatCmd,I_CDCU_PsngrSeatHeatCmd,I_CDCU_SecRowLtSeatHeatCmd,I_CDCU_SecRowRtSeatHeatCmd 4:0,4:0,4:0,4:0 3;50;50
}

testcase SYS_CDCU_jisushengwen_0061()
{
  TestDescription("急速升温联动方向盘加热 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-急速升温-0061");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2
  g_CAN_Bus_Swc_Set("I_LDCU_SeatInfo.I_LDCU_DrvSeatHeatSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_SeatInfo.I_LDCU_DrvSeatHeatSt 0//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo.I_RDCU_PsngrSeatHeatSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo.I_RDCU_PsngrSeatHeatSt 0//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_LDCU_SeatInfo.I_LDCU_SecRowLtSeatHeatSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_SeatInfo.I_LDCU_SecRowLtSeatHeatSt 0//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_RDCU_SeatInfo.I_RDCU_SecRowRtSeatHeatSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_SeatInfo.I_RDCU_SecRowRtSeatHeatSt 0//设置联动之前的状态
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt2.I_LDCU_SWSHeatSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt2.I_LDCU_SWSHeatSt 0//设置联动之前的状态
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 3"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.Veh_TurnOnOffMaxHeatingNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffMaxHeatingStruct.TurnOnOffMaxHeating 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxWarmingSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxWarmingSt:1//
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 3:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 3:0 3;50;50
  g_CAN_Bus_Swc_CheckEventStart("I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 4"); // 测试步骤 TC_CANTest CheckEventStart I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 4
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.MaxWarmingSt:0"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.MaxWarmingSt:0//
  g_CAN_Bus_Swc_CheckPeriod_FilterStarted("I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 4:0 3;50;50"); // 预期结果 TC_CANTest CheckPeriod_FilterStarted I_CDCU_LDCU_BodyCtrl.I_CDCU_LDCU_SWSHeatCmd 4:0 3;50;50
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0062()
{
  TestDescription("设置吹脸 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0062");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:1//Face
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 0"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0063()
{
  TestDescription("设置吹脸 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0063");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:3"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:3//Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0064()
{
  TestDescription("设置吹脸 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0064");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:6"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:6//Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 0//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 0//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0065()
{
  TestDescription("设置吹脸 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0065");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:6"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:6//Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0066()
{
  TestDescription("设置吹脸 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0066");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:2//Face_foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0067()
{
  TestDescription("设置吹脸 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0067");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:4"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:4//Foot_windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0068()
{
  TestDescription("设置吹脸 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0068");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:4"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:4//Foot_windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0069()
{
  TestDescription("设置吹脸 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0069");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:8"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:8//Face_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0070()
{
  TestDescription("设置吹脸 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0070");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:9"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:9//Face_Foot_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0071()
{
  TestDescription("设置吹脸 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0071");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:0xD"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:0xD//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0072()
{
  TestDescription("设置吹脸 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0072");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:0xE"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:0xE//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0073()
{
  TestDescription("设置吹脸 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0073");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:0xF"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:0xF//
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0074()
{
  TestDescription("设置吹脚 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0074");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:3"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:3//Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3&MemoryReq 0//Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3&MemoryReq 0//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0075()
{
  TestDescription("设置吹脚 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0075");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:1//Face
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0076()
{
  TestDescription("设置吹脚 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0076");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:6"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:6//Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0077()
{
  TestDescription("设置吹脚 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0077");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:2//Face_foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0078()
{
  TestDescription("设置吹脚 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0078");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:4"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:4//Foot_windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0079()
{
  TestDescription("设置吹脚 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0079");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:8"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:8//Face_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0080()
{
  TestDescription("设置吹脚 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0080");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:9"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:9//Face_Foot_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0081()
{
  TestDescription("设置吹窗 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0081");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:6"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:6//Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 6&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6&MemoryReq 0//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 6&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6&MemoryReq 0//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0082()
{
  TestDescription("设置吹窗 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0082");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:1//Face
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0083()
{
  TestDescription("设置吹窗 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0083");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:1//Face
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5&MemoryReq 1//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0084()
{
  TestDescription("设置吹窗 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0084");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:2//Face_foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0085()
{
  TestDescription("设置吹窗 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0085");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:2//Face_foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0086()
{
  TestDescription("设置吹窗 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0086");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:4"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:4//Foot_windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0087()
{
  TestDescription("设置吹窗 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0087");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:8"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:8//Face_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0088()
{
  TestDescription("设置吹窗 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0088");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.AirDistributionMode:9"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.AirDistributionMode:9//Face_Foot_Windshield
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrAirDisModeBtnStruct.Veh_FrAirDisModeBtn:1&ServiceExecuteFeedbackFlag:2//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrAirDisModeBtnRespStruct.Veh_FrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0089()
{
  TestDescription("前排吹风模式设置(语音) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0089");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:1&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0090()
{
  TestDescription("前排吹风模式设置(语音) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0090");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Face_foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0091()
{
  TestDescription("前排吹风模式设置(语音) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0091");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:3&ServiceExecuteFeedbackFlag:2//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 3//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0092()
{
  TestDescription("前排吹风模式设置(语音) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0092");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:4&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:4&ServiceExecuteFeedbackFlag:2//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 4"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 4//Foot_windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0093()
{
  TestDescription("前排吹风模式设置(语音) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0093");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:5&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:5&ServiceExecuteFeedbackFlag:2//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 5"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 5//Face_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0094()
{
  TestDescription("前排吹风模式设置(语音) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0094");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:6&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:6&ServiceExecuteFeedbackFlag:2//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 6"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 6//Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0095()
{
  TestDescription("前排吹风模式设置(语音) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0095");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:7&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetFrAirDisModeStruct.Veh_SetFrAirDisMode:7&ServiceExecuteFeedbackFlag:2//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetFrAirDisModeRespStruct.Veh_SetFrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetFrAirDisModeStruct.SetFrAirDisMode 7"); // 预期结果 TC_CANTest SOA CheckReq SetFrAirDisModeStruct.SetFrAirDisMode 7//Face_Foot_Windshield
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0096()
{
  TestDescription("设置吹脸 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0096");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:1//Face
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0097()
{
  TestDescription("设置吹脸 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0097");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:2//Face_Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 1//Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 1//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0098()
{
  TestDescription("设置吹脸 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0098");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:3"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:3//Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0099()
{
  TestDescription("设置吹脸 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0099");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:14"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:14//OFF
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:2&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0100()
{
  TestDescription("设置吹脚 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0100");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:3"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:3//Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 0//Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3&MemoryReq 0//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0101()
{
  TestDescription("设置吹脚 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0101");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:2"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:2//Face_Foot
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 1//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0102()
{
  TestDescription("设置吹脚 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0102");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:1"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:1//Face
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 2"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0103()
{
  TestDescription("设置吹脚 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0103");
  gTC_CANTest_SOA_SetSever("AirDistributionModeStruct.RearAirDistributionMode:14"); // 测试步骤 TC_CANTest SOA SetServer AirDistributionModeStruct.RearAirDistributionMode:14//OFF
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrAirDisModeBtnStruct.Veh_RrAirDisModeBtn:3&ServiceExecuteFeedbackFlag:2//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrAirDisModeBtnRespStruct.Veh_RrAirDisModeBtnNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0104()
{
  TestDescription("二排吹风模式设置(语音) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0104");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:1&ServiceExecuteFeedbackFlag:2//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 1&MemoryReq 0//Face
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0105()
{
  TestDescription("二排吹风模式设置(语音) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0105");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 2&MemoryReq 1//Face_Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0106()
{
  TestDescription("二排吹风模式设置(语音) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0106");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3//Foot
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:3&ServiceExecuteFeedbackFlag:2//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 3"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 3//Foot
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0107()
{
  TestDescription("二排吹风模式设置(语音) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0107");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 13"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 13//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:13&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:13&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 13"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 13//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_chuifengmoshishezhiIGON_0108()
{
  TestDescription("二排吹风模式设置(语音) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-吹风模式设置IGON-0108");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetRrAirDisModeStruct.SetRrAirDisMode 14"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 14//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:14&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetRrAirDisModeStruct.Veh_SetRrAirDisMode:14&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetRrAirDisModeRespStruct.Veh_SetRrAirDisModeNRC 0
  gTC_CANTest_SOA_CheckReq("SetRrAirDisModeStruct.SetRrAirDisMode 14"); // 预期结果 TC_CANTest SOA CheckReq SetRrAirDisModeStruct.SetRrAirDisMode 14//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_dakaiqiankongdiao_0109()
{
  TestDescription("打开前空调 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-打开前空调-0109");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnFrACStruct.TurnOnFrAC 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnFrACStruct.TurnOnFrAC 0//MemoAC
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&MemoryReq:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&MemoryReq:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnFrACStruct.TurnOnFrAC 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnFrACStruct.TurnOnFrAC 0//MemoAC
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_guanbiqiankongdiao_0110()
{
  TestDescription("关闭前空调 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-关闭前空调-0110");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 0"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&MemoryReq:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&MemoryReq:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_dakaiqiankongdiao_0111()
{
  TestDescription("打开前空调 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-打开前空调-0111");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnFrACStruct.TurnOnFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnFrACStruct.TurnOnFrAC 1//Def
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnFrACStruct.TurnOnFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnFrACStruct.TurnOnFrAC 1//Def
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_guanbiqiankongdiao_0112()
{
  TestDescription("关闭前空调 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-关闭前空调-0112");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 0"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.Veh_TurnOnOffFrACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_dakaihoukongdiao_0113()
{
  TestDescription("打开后空调 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-打开后空调-0113");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnRrACStruct.TurnOnRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnRrACStruct.TurnOnRrAC 1//MemoAC
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay6.8"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay6.8 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnRrACStruct.TurnOnRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnRrACStruct.TurnOnRrAC 1//MemoAC
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay6.8"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay6.8 //检查RESPONSE
}

testcase SYS_CDCU_guanbihoukongdiao_0114()
{
  TestDescription("关闭后空调 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-关闭后空调-0114");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 0"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay6.8"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay6.8 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffRrACStruct.TurnOffRrAC 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay6.8"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay6.8 //检查RESPONSE
}

testcase SYS_CDCU_dakaihoukongdiao_0115()
{
  TestDescription("打开后空调 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-打开后空调-0115");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnRrACStruct.TurnOnRrAC 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnRrACStruct.TurnOnRrAC 0//MemoAC
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay6.8"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay6.8 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&MemoryReq:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&MemoryReq:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnRrACStruct.TurnOnRrAC 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnRrACStruct.TurnOnRrAC 0//MemoAC
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay6.8"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay6.8 //检查RESPONSE
}

testcase SYS_CDCU_guanbihoukongdiao_0116()
{
  TestDescription("关闭后空调 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-关闭后空调-0116");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 0"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffRrACStruct.TurnOffRrAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay6.8"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay6.8 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2&MemoryReq:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2&MemoryReq:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.Veh_TurnOnOffRrACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffRrACStruct.TurnOffRrAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOffRrACStruct.TurnOffRrAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay6.8"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay6.8 //检查RESPONSE
}

testcase SYS_CDCU_dakaiqiankongdiaozidongmoshi_0117()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-打开前空调自动模式-0117");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 2//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 2"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_dakaiqiankongdiaozidongmoshi_0118()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-打开前空调自动模式-0118");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 0"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_dakaiqiankongdiaozidongmoshi_0119()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-打开前空调自动模式-0119");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.Veh_TurnOnOffFrAutoACNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffFrAutoACStruct.TurnOnOffFrAutoAC 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijun_0120()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌-0120");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_CAN_Bus_Swc_Set("I_RDCU_SunRoofWindowCtrl.I_RoofPosValue 0"); // 测试步骤 TC_CANTest SET I_RDCU_SunRoofWindowCtrl.I_RoofPosValue 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijun_0121()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌-0121");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjie_0122()
{
  TestDescription("ON Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁-0122");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjie_0123()
{
  TestDescription("OFF Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁-0123");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//OFF//TC_CANTest SOA CheckReq RestoreAcToMemoStStruct.RestoreAcToMemoSt 1//Active
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.UserID:0x01010001&Veh_TurnOnOffACSelfClean:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.UserID:0x01010001&Veh_TurnOnOffACSelfClean:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//OFF//TC_CANTest SOA CheckReq RestoreAcToMemoStStruct.RestoreAcToMemoSt 1//Active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijun_0124()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌-0124");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_RDCU_NM.I_RDCU_NMRepeatMsgReqBit 1"); // 测试步骤 TC_CANTest SET I_RDCU_NM.I_RDCU_NMRepeatMsgReqBit 1 //网络唤醒维持帧
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijun_0125()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌-0125");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijun_0126()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌-0126");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijun_0127()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌-0127");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("RestoreAcToMemoStStruct.RestoreAcToMemoSt 1"); // 预期结果 TC_CANTest SOA CheckReq RestoreAcToMemoStStruct.RestoreAcToMemoSt 1//Active
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("RestoreAcToMemoStStruct.RestoreAcToMemoSt 1"); // 预期结果 TC_CANTest SOA CheckReq RestoreAcToMemoStStruct.RestoreAcToMemoSt 1//Active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjie_0128()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁-0128");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjie_0129()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁-0129");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("RestoreAcToMemoStStruct.RestoreAcToMemoSt 1"); // 预期结果 TC_CANTest SOA CheckReq RestoreAcToMemoStStruct.RestoreAcToMemoSt 1//Active
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("RestoreAcToMemoStStruct.RestoreAcToMemoSt 1"); // 预期结果 TC_CANTest SOA CheckReq RestoreAcToMemoStStruct.RestoreAcToMemoSt 1//Active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjie_0130()
{
  TestDescription("ON Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁-0130");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("SetACSelfCleanStruct.SetACSelfClean 1"); // 预期结果 TC_CANTest SOA CheckReq SetACSelfCleanStruct.SetACSelfClean 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziqingjie_0131()
{
  TestDescription("OFF Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-空调自清洁-0131");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//OFF//TC_CANTest SOA CheckReq RestoreAcToMemoStStruct.RestoreAcToMemoSt 1//Active
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.UserID:0x01010001&Veh_TurnOnOffACSelfClean:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.UserID:0x01010001&Veh_TurnOnOffACSelfClean:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.Veh_TurnOnOffACSelfCleanNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0//OFF//TC_CANTest SOA CheckReq RestoreAcToMemoStStruct.RestoreAcToMemoSt 1//Active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qianchushuang_0132()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-前除霜-0132");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qianchushuang_0133()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-前除霜-0133");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffDefrostStruct.TurnOnOffDefrost 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_qianchushuang_0134()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-前除霜-0134");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.Veh_TurnOnOffDefrostNRC 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhinengchuwei_0135()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-智能除味-0135");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq("SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhinengchuwei_0136()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-智能除味-0136");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq("SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetOnOffDeodorizeStruct.SetOnOffDeodorize 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_zhinengchuwei_0137()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-智能除味-0137");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("RestoreAcToMemoStStruct.RestoreAcToMemoSt 1"); // 预期结果 TC_CANTest SOA CheckReq RestoreAcToMemoStStruct.RestoreAcToMemoSt 1//Active
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.Veh_SetOnOffDeodorizeNRC 0
  gTC_CANTest_SOA_CheckReq("RestoreAcToMemoStStruct.RestoreAcToMemoSt 1"); // 预期结果 TC_CANTest SOA CheckReq RestoreAcToMemoStStruct.RestoreAcToMemoSt 1//Active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_houkongdiaowugantongfeng_0138()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-后空调无感通风-0138");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_houkongdiaowugantongfeng_0139()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-后空调无感通风-0139");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_houkongdiaowugantongfeng_0140()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-后空调无感通风-0140");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffInsenVentStruct.Veh_TurnOnOffInsenVent:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffInsenVentRespStruct.Veh_TurnOnOffInsenVentNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffInsenVentStruct.TurnOnOffInsenVent 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziganzao_0141()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自干燥-0141");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:2&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq("SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziganzao_0142()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自干燥-0142");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:2&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq("SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziganzao_0143()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自干燥-0143");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq("SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaoziganzao_0144()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调自干燥-0144");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetACAfterBlowStruct.Veh_SetACAfterBlow:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetACAfterBlowRespStruct.Veh_SetACAfterBlowNRC 0
  gTC_CANTest_SOA_CheckReq("SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetACAfterBlowStruct.SetACAfterBlow 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wenqutongbu_0145()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温区同步-0145");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetSyncStruct.SetSync 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetSyncStruct.Veh_SetSync:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetSyncStruct.Veh_SetSync:2&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq("SetSyncStruct.SetSync 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wenqutongbu_0146()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温区同步-0146");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetSyncStruct.SetSync 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetSyncStruct.Veh_SetSync:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetSyncStruct.Veh_SetSync:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq("SetSyncStruct.SetSync 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wenqutongbu_0147()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温区同步-0147");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetSyncStruct.SetSync 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetSyncStruct.Veh_SetSync:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetSyncStruct.Veh_SetSync:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq("SetSyncStruct.SetSync 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_wenqutongbu_0148()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-温区同步-0148");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetSyncStruct.SetSync 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetSyncStruct.Veh_SetSync:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetSyncStruct.Veh_SetSync:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetSyncRespStruct.Veh_SetSyncNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetSyncRespStruct.Veh_SetSyncNRC 0
  gTC_CANTest_SOA_CheckReq("SetSyncStruct.SetSync 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetSyncStruct.SetSync 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0149()
{
  TestDescription("设置前空调风量(步进加) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0149");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:0"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:0//OFF
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0150()
{
  TestDescription("设置前空调风量(步进加) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0150");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:1"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:1//Level 1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0151()
{
  TestDescription("设置前空调风量(步进加) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0151");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:2"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:2//Level 2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0152()
{
  TestDescription("设置前空调风量(步进加) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0152");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:3"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:3//Level 3
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0153()
{
  TestDescription("设置前空调风量(步进加) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0153");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:4"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:4//Level 4
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0154()
{
  TestDescription("设置前空调风量(步进加) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0154");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:5"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:5//Level 5
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0155()
{
  TestDescription("设置前空调风量(步进加) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0155");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:6"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:6//Level 6
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0156()
{
  TestDescription("设置前空调风量(步进加) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0156");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:7"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:7//Level 7
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 8"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 8"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0157()
{
  TestDescription("设置前空调风量(步进加) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0157");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:8"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:8//Level 8
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 9"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 9"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0158()
{
  TestDescription("设置前空调风量(步进加) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0158");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:9"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:9//Level 9
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 10"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 10"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0159()
{
  TestDescription("设置前空调风量(步进加) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0159");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:10"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:10//Level 10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 10&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdUpStruct.Veh_FrWindSpdUp:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdUpRespStruct.Veh_FrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 10&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0160()
{
  TestDescription("设置前空调风量(目标设置) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0160");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 0&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 0&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:0&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:0&MemoryReq:1&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 0&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 0&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0161()
{
  TestDescription("设置前空调风量(目标设置) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0161");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:1&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0162()
{
  TestDescription("设置前空调风量(目标设置) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0162");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 2"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:2&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 2"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0163()
{
  TestDescription("设置前空调风量(目标设置) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0163");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:3&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0164()
{
  TestDescription("设置前空调风量(目标设置) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0164");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:4&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:4&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0165()
{
  TestDescription("设置前空调风量(目标设置) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0165");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:5&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:5&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0166()
{
  TestDescription("设置前空调风量(目标设置) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0166");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:6&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:6&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0167()
{
  TestDescription("设置前空调风量(目标设置) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0167");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:7&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:7&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0168()
{
  TestDescription("设置前空调风量(目标设置) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0168");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 8"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:8&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:8&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 8"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0169()
{
  TestDescription("设置前空调风量(目标设置) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0169");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 9"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:9&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:9&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 9"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0170()
{
  TestDescription("设置前空调风量(目标设置) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0170");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 10"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:10&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlFrWindSpdStruct.Veh_CtrlFrWindSpd:10&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlFrWindSpdRespStruct.Veh_CtrlFrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 10"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0171()
{
  TestDescription("设置前空调风量(步进减) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0171");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:10"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:10//Level 10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 9&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 9&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 9&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0172()
{
  TestDescription("设置前空调风量(步进减) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0172");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:9"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:9//Level 9
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 8&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 8&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 8&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0173()
{
  TestDescription("设置前空调风量(步进减) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0173");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:8"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:8//Level 8
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 7"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 7
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0174()
{
  TestDescription("设置前空调风量(步进减) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0174");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:7"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:7//Level 7
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 6"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 6
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0175()
{
  TestDescription("设置前空调风量(步进减) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0175");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:6"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:6//Level 6
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0176()
{
  TestDescription("设置前空调风量(步进减) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0176");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:5"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:5//Level 5
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0177()
{
  TestDescription("设置前空调风量(步进减) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0177");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:4"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:4//Level 4
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0178()
{
  TestDescription("设置前空调风量(步进减) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0178");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:3"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:3//Level 3
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 2"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 2"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0179()
{
  TestDescription("设置前空调风量(步进减) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0179");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:2"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:2//Level 2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0180()
{
  TestDescription("设置前空调风量(步进减) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0180");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.WindExitSpd:1"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.WindExitSpd:1//Level 1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlFrWindSpdStruct.CtrlFrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_FrWindSpdDownStruct.Veh_FrWindSpdDown:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_FrWindSpdDownRespStruct.Veh_FrWindSpdDownNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlFrWindSpdStruct.CtrlFrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlFrWindSpdStruct.CtrlFrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0181()
{
  TestDescription("设后空调风量(步进加) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0181");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:0"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:0//Level 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0182()
{
  TestDescription("设后空调风量(步进加) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0182");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:1"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:1//Level 1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 2&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 2&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0183()
{
  TestDescription("设后空调风量(步进加) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0183");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:2"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:2//Level 2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 3"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 3
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0184()
{
  TestDescription("设后空调风量(步进加) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0184");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:3"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:3//Level 3
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 4"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 4
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0185()
{
  TestDescription("设后空调风量(步进加) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0185");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:4"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:4//Level 4
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0186()
{
  TestDescription("设后空调风量(步进加) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0186");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:5"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:5//Level 5
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdUpStruct.Veh_RrWindSpdUp:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdUpRespStruct.Veh_RrWindSpdUpNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 5"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0187()
{
  TestDescription("设后空调风量(目标设置) Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0187");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_CtrlRrWindSpdRespStruct.Veh_CtrlRrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlRrWindSpdRespStruct.Veh_CtrlRrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_CtrlRrWindSpdStruct.Veh_CtrlRrWindSpd:5&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_CtrlRrWindSpdStruct.Veh_CtrlRrWindSpd:5&MemoryReq:1&ServiceExecuteFeedbackFlag:2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_CtrlRrWindSpdRespStruct.Veh_CtrlRrWindSpdNRC 0"); // 预期结果 TC_CANTest SOA check Veh_CtrlRrWindSpdRespStruct.Veh_CtrlRrWindSpdNRC 0 //检查RESPONSE
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 5&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 5&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0188()
{
  TestDescription("设后空调风量（步进减） Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0188");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:5"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:5//Level 5
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 4&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 4&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 4&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 4&MemoryReq 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0189()
{
  TestDescription("设后空调风量（步进减） Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0189");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:4"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:4//Level 4
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 3&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 3&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 3&MemoryReq 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0190()
{
  TestDescription("设后空调风量（步进减） Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0190");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:3"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:3//Level 3
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 2"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 2"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0191()
{
  TestDescription("设后空调风量（步进减） Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0191");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:2"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:2//Level 2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaofengliangdiaojie_0192()
{
  TestDescription("设后空调风量（步进减） Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调风量调节-0192");
  gTC_CANTest_SOA_SetSever("WindExitSpdStruct.RWindExitSpd:1"); // 测试步骤 TC_CANTest SOA SetServer WindExitSpdStruct.RWindExitSpd:1//Level 1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("CtrlRrWindSpdStruct.CtrlRrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_RrWindSpdDownStruct.Veh_RrWindSpdDown:1&ServiceExecuteFeedbackFlag:2//active
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0"); // 预期结果 TC_CANTest SOA check Veh_RrWindSpdDownRespStruct.Veh_RrWindSpdDownNRC 0
  gTC_CANTest_SOA_CheckReq("CtrlRrWindSpdStruct.CtrlRrWindSpd 1"); // 预期结果 TC_CANTest SOA CheckReq CtrlRrWindSpdStruct.CtrlRrWindSpd 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_neixunhuan_0193()
{
  TestDescription("内循环 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-内循环-0193");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 0"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetAirIntakeStruct.SetAirIntake 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 1&MemoryReq 0//
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetAirIntakeStruct.Veh_SetAirIntake:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetAirIntakeStruct.Veh_SetAirIntake:1&ServiceExecuteFeedbackFlag:2//内循环
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq("SetAirIntakeStruct.SetAirIntake 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 1&MemoryReq 0//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_neixunhuan_0194()
{
  TestDescription("内循环 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-内循环-0194");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetAirIntakeStruct.SetAirIntake 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 1&MemoryReq 1//
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetAirIntakeStruct.Veh_SetAirIntake:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetAirIntakeStruct.Veh_SetAirIntake:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2//内循环
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq("SetAirIntakeStruct.SetAirIntake 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 1&MemoryReq 1//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_waixunhuan_0195()
{
  TestDescription("外循环 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-外循环-0195");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetAirIntakeStruct.SetAirIntake 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 2&MemoryReq 0//
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetAirIntakeStruct.Veh_SetAirIntake:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetAirIntakeStruct.Veh_SetAirIntake:2&ServiceExecuteFeedbackFlag:2//外循环
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq("SetAirIntakeStruct.SetAirIntake 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 2&MemoryReq 0//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_waixunhuan_0196()
{
  TestDescription("外循环 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-外循环-0196");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetAirIntakeStruct.SetAirIntake 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 2&MemoryReq 1//
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetAirIntakeStruct.Veh_SetAirIntake:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetAirIntakeStruct.Veh_SetAirIntake:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//外循环
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetAirIntakeRespStruct.Veh_SetAirIntakeNRC 0
  gTC_CANTest_SOA_CheckReq("SetAirIntakeStruct.SetAirIntake 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq SetAirIntakeStruct.SetAirIntake 2&MemoryReq 1//
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_shezhikongdiaojienengmoshi_0197()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-设置空调节能模式-0197");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:2&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq("setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_shezhikongdiaojienengmoshi_0198()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-设置空调节能模式-0198");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq("setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_shezhikongdiaojienengmoshi_0199()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-设置空调节能模式-0199");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq("setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_shezhikongdiaojienengmoshi_0200()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-设置空调节能模式-0200");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffECOModeStruct.Veh_SetOnOffECOMode:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffECOModeRespStruct.Veh_SetOnOffECOModeNRC 0
  gTC_CANTest_SOA_CheckReq("setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq setOnOffECOModeStruct.setOnOffECOMode 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_AQSgongneng_0201()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-AQS功能-0201");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:2&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_AQSgongneng_0202()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-AQS功能-0202");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_AQSgongneng_0203()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-AQS功能-0203");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_AQSgongneng_0204()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-AQS功能-0204");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAQSStruct.Veh_TurnOnOffAQS:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAQSRespStruct.Veh_TurnOnOffAQSNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAQSStruct.TurnOnOffAQS 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongqijinghuagongneng_0205()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空气净化功能-0205");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:2&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:2&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 0//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongqijinghuagongneng_0206()
{
  TestDescription("ON Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空气净化功能-0206");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 2&MemoryReq 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongqijinghuagongneng_0207()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空气净化功能-0207");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 0//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongqijinghuagongneng_0208()
{
  TestDescription("OFF Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空气净化功能-0208");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffAirCleanStruct.Veh_TurnOnOffAirClean:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffAirCleanRespStruct.Veh_TurnOnOffAirCleanNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffAirCleanStruct.TurnOnOffAirClean 1&MemoryReq 1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaolengnuantongfenggongneng_0209()
{
  TestDescription("打开空调冷暖通风功能 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调冷暖通风功能-0209");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOFFHCVStruct.TurnOnOFFHCV 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 1&MemoryReq 0//CoolingOn
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:1&ServiceExecuteFeedbackFlag:2//CoolingOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOFFHCVStruct.TurnOnOFFHCV 1&MemoryReq 0"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 1&MemoryReq 0//CoolingOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaolengnuantongfenggongneng_0210()
{
  TestDescription("打开空调冷暖通风功能 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调冷暖通风功能-0210");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOFFHCVStruct.TurnOnOFFHCV 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 2&MemoryReq 1//HeatOn
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:2&MemoryReq:1&ServiceExecuteFeedbackFlag:2//HeatOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOFFHCVStruct.TurnOnOFFHCV 2&MemoryReq 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 2&MemoryReq 1//HeatOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaolengnuantongfenggongneng_0211()
{
  TestDescription("打开空调冷暖通风功能 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调冷暖通风功能-0211");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOFFHCVStruct.TurnOnOFFHCV 3"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 3//VentilateOn
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:3&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:3&ServiceExecuteFeedbackFlag:2//VentilateOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOFFHCVStruct.TurnOnOFFHCV 3"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 3//VentilateOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_kongdiaolengnuantongfenggongneng_0212()
{
  TestDescription("打开空调冷暖通风功能 Power=ON");
  teststep("warning","原始用例id为SYS-CDCU-空调冷暖通风功能-0212");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOFFHCVStruct.TurnOnOFFHCV 4"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 4//AutoHCVOn
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:4&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOFFHCVStruct.Veh_TurnOnOFFHCV:4&ServiceExecuteFeedbackFlag:2//AutoHCVOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOFFHCVRespStruct.Veh_TurnOnOFFHCVNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOFFHCVStruct.TurnOnOFFHCV 4"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOFFHCVStruct.TurnOnOFFHCV 4//AutoHCVOn
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0213()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0213");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON打开高温抑菌
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0214()
{
  TestDescription("LDCU_dstBatDisp≤100 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0214");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 2//HVAC_HIGH_TEMP_STOP_LOW_SOC
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 50"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 50
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 2//HVAC_HIGH_TEMP_STOP_LOW_SOC
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0215()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0215");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON打开高温抑菌
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0216()
{
  TestDescription("LDCU_dstBatDisp≤100 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0216");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 2//HVAC_HIGH_TEMP_STOP_LOW_SOC
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 100"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 100
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 2//HVAC_HIGH_TEMP_STOP_LOW_SOC
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0217()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0217");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON打开高温抑菌
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0218()
{
  TestDescription("LDCU_dstBatDisp丢失 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0218");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 2//HVAC_HIGH_TEMP_STOP_LOW_SOC
  g_CAN_Bus_Swc_Disable("I_LDCU_SysStDisp1"); // 测试步骤 TC_CANTest Disable I_LDCU_SysStDisp1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 2//HVAC_HIGH_TEMP_STOP_LOW_SOC
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0219()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0219");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON打开高温抑菌
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0220()
{
  TestDescription("LDCU_dstBatDisp>100 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0220");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 102"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 102
  g_EM_SOAClient_Swc_SOA_CHECKNotRec("Veh_HVACRemotePushStruct.Veh_DisinfStPush timeoutS3"); // 预期结果 TC_CANTest SOA CheckNotRec Veh_HVACRemotePushStruct.Veh_DisinfStPush timeoutS3
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0221()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0221");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0222()
{
  TestDescription("LDCU_ChrgConnSt_Disp=AC Charge connector  connected Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0222");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 3"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 3//HVAC_HIGH_TEMP_STOP_SLOW_CHARGING
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 1//AC Charge
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 3"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 3//HVAC_HIGH_TEMP_STOP_SLOW_CHARGING
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0223()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0223");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 7"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 7
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0224()
{
  TestDescription("LDCU_ChrgConnSt_Disp=DC Charge connector  connected Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0224");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 3"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 3//HVAC_HIGH_TEMP_STOP_SLOW_CHARGING
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 3"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 3//HVAC_HIGH_TEMP_STOP_SLOW_CHARGING
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 2
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0225()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0225");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0226()
{
  TestDescription("LDCU_dstBatDisp 信号丢失 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0226");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 200
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("1"); // 测试步骤 TC_Sleep 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 2//HVAC_HIGH_TEMP_STOP_LOW_SOC
  g_CAN_Bus_Swc_Disable("I_LDCU_SysStDisp1"); // 测试步骤 TC_CANTest Disable I_LDCU_SysStDisp1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 2//HVAC_HIGH_TEMP_STOP_LOW_SOC
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0227()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0227");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0228()
{
  TestDescription("LDCU_DriverDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0228");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_ChrgConnSt_Disp 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0229()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0229");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0230()
{
  TestDescription("LDCU_FLWinPosStFB ＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0230");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0231()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0231");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0232()
{
  TestDescription("LDCU_RLDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0232");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0233()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0233");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0234()
{
  TestDescription("RDCU_FRWinPosStFB ＞ 4% Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0234");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:10"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:10
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 1 traceback2//HVAC_HIGH_TEMP_STOP_WINDOW_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0235()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0235");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0236()
{
  TestDescription("RDCU_PsngrDoorAjarSt==Open Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0236");
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_RLDoorAjarSt 0
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACRemotePushStruct.Veh_DisinfStPush 5"); // 预期结果 TC_CANTest SOA check Veh_HVACRemotePushStruct.Veh_DisinfStPush 5//HVAC_HIGH_TEMP_STOP_DOOR_NOT_CLOSED
  gTC_CANTest_SOA_CheckReq("TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2"); // 预期结果 TC_CANTest SOA CheckReq TurnOffFrACStruct.TurnOffFrAC 1&MemoryReq 0 traceback2
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0237()
{
  TestDescription("打开高温抑菌 Power=Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-高温抑菌远控空调异常状态信息推送-0237");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.DisinfSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.DisinfSt:1//ON
  gTC_CANTest_SOA_SetSever("ACSysStateStruct.ACPowerSt:1"); // 测试步骤 TC_CANTest SOA SetServer ACSysStateStruct.ACPowerSt:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.Veh_TurnOnOffSterilizationNRC 0
  gTC_CANTest_SOA_CheckReq("TurnOnOffSterilizationStruct.TurnOnOffSterilization 1"); // 预期结果 TC_CANTest SOA CheckReq TurnOnOffSterilizationStruct.TurnOnOffSterilization 1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_gaowenyijunyuankongkongdiaoyichangzhuangtaixinxituisong_0238()
{
  TestDescription("RDCU_RRWinPosStFB＞ 4% Power=Remote ON");
