  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xE&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xE"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xE //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_diandongchufengkoufujiayoucechuizhiweizhidiaojie_1323()
{
  TestDescription("0xF:Error Power=OFF");
  teststep("warning","原始用例id为SYS-CDCU-电动出风口副驾右侧垂直位置调节-1323");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq_Prepare("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001"); // 测试步骤 TC_CANTest SOA REQ Veh_SetEAVPsnRightVertPosStruct.Veh_SetEAVPsnRightVertPos:0xF&ServiceExecuteFeedbackFlag:2&UserID:0x01010001//Error
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0"); // 预期结果 TC_CANTest SOA check Veh_SetEAVPsnRightVertPosRespStruct.Veh_SetEAVPsnRightVertPosNRC 0
  gTC_CANTest_SOA_CheckReq("SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xF"); // 预期结果 TC_CANTest SOA CheckReq SetEAVPsnRightVertPosStruct.SetEAVPsnRightVertPos 0xF //
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 0 delay8.1 //检查RESPONSE
}

testcase SYS_CDCU_Service_Err_1324()
{
  TestDescription("原子服务回复超时 Remote ON");
  g_EM_Equipment_Swc_TC_PW("ON"); // 测试步骤 TC_PW ON
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_EM_SOAClient_Swc_SOA_SubPeriod("Veh_HVACService_ErrGrp 1"); // 测试步骤 TC_CANTest SOA SubPeriod Veh_HVACService_ErrGrp 1
  g_EM_SOAClient_Swc_SOA_SubPeriod("Veh_HVACPush 1"); // 测试步骤 TC_CANTest SOA SubPeriod Veh_HVACPush 1
}

testcase SYS_CDCU_Service_Err_1325()
{
  TestDescription("开启空调控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
}

testcase SYS_CDCU_Service_Err_1326()
{
  TestDescription("开启空调控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
}

testcase SYS_CDCU_Service_Err_1327()
{
  TestDescription("开启空调控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
}

testcase SYS_CDCU_Service_Err_1328()
{
  TestDescription("开启空调控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
}

testcase SYS_CDCU_Service_Err_1329()
{
  TestDescription("开启空调控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
}

testcase SYS_CDCU_Service_Err_1330()
{
  TestDescription("开启空调控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
}

testcase SYS_CDCU_Service_Err_1331()
{
  TestDescription("关闭空调控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
}

testcase SYS_CDCU_Service_Err_1332()
{
  TestDescription("关闭空调控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
}

testcase SYS_CDCU_Service_Err_1333()
{
  TestDescription("关闭空调控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
}

testcase SYS_CDCU_Service_Err_1334()
{
  TestDescription("关闭空调控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
}

testcase SYS_CDCU_Service_Err_1335()
{
  TestDescription("关闭空调控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  gTC_CANTest_SOA_Set8001Delay("20"); // 预期结果 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
}

testcase SYS_CDCU_Service_Err_1336()
{
  TestDescription("主驾温度调节控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F traceback20
}

testcase SYS_CDCU_Service_Err_1337()
{
  TestDescription("主驾温度调节控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetDrvTempRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetDrvTempRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F traceback20
}

testcase SYS_CDCU_Service_Err_1338()
{
  TestDescription("开启极速升温控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2847 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2847 traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2847 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2847 traceback20
}

testcase SYS_CDCU_Service_Err_1339()
{
  TestDescription("关闭极速升温控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2848 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2848 traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2848 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2848 traceback20
}

testcase SYS_CDCU_Service_Err_1340()
{
  TestDescription("开启极速降温控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2845 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2845 traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2845 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2845 traceback20
}

testcase SYS_CDCU_Service_Err_1341()
{
  TestDescription("关闭极速降温控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2846 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2846 traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2846 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2846 traceback20
}

testcase SYS_CDCU_Service_Err_1342()
{
  TestDescription("开启高温抑菌控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284E traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284E traceback20
}

testcase SYS_CDCU_Service_Err_1343()
{
  TestDescription("关闭高温抑菌控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284D traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284D traceback20
}

testcase SYS_CDCU_Service_Err_1344()
{
  TestDescription("电量较低_开启高温抑菌控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 100,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 100,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_Set8001Delay("0"); // 测试步骤 TC_CANTest SOA Set8001Delay 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 6 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284B"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284B
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 6 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284B"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284B
}

testcase SYS_CDCU_Service_Err_1345()
{
  TestDescription("车窗未关_开启高温抑菌控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 预期结果 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 预期结果 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 预期结果 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:100"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:100
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:100"); // 预期结果 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:100
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 预期结果 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 预期结果 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 预期结果 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 预期结果 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 预期结果 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 预期结果 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
}

testcase SYS_CDCU_Service_Err_1346()
{
  TestDescription("车窗未关_开启高温抑菌控制失败 Remote ON");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:100"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:100
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A
}

testcase SYS_CDCU_Service_Err_1347()
{
  TestDescription("车窗未关_开启高温抑菌控制失败 Remote ON");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:100"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:100
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A
}

testcase SYS_CDCU_Service_Err_1348()
{
  TestDescription("车窗未关_开启高温抑菌控制失败 Remote ON");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:100"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:100
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A
}

testcase SYS_CDCU_Service_Err_1349()
{
  TestDescription("后备箱未关_开启高温抑菌控制失败 Remote ON");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 3"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 3
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
}

testcase SYS_CDCU_Service_Err_1350()
{
  TestDescription("正在慢充_开启高温抑菌控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 2"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 192 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 192 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284C"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284C
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 192 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 192 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284C"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284C
}

testcase SYS_CDCU_Service_Err_1351()
{
  TestDescription("正在慢充_开启高温抑菌控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 1"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 1
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 192 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 192 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284C"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284C
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 192 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 192 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284C"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284C
}

testcase SYS_CDCU_Service_Err_1352()
{
  TestDescription("车门未关_开启高温抑菌控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
}

testcase SYS_CDCU_Service_Err_1353()
{
  TestDescription("车门未关_开启高温抑菌控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 1
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
}

testcase SYS_CDCU_Service_Err_1354()
{
  TestDescription("车门未关_开启高温抑菌控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
}

testcase SYS_CDCU_Service_Err_1355()
{
  TestDescription("车门未关_开启高温抑菌控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 1,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 1,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
}

testcase SYS_CDCU_Service_Err_1356()
{
  TestDescription("车门未关_开启高温抑菌控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 2"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 2
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
}

testcase SYS_CDCU_Service_Err_1357()
{
  TestDescription("开启空调自清洁控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A traceback20
}

testcase SYS_CDCU_Service_Err_1358()
{
  TestDescription("关闭空调自清洁控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A traceback20
}

testcase SYS_CDCU_Service_Err_1359()
{
  TestDescription("电量较低_开启空调自清洁控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 100,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 100,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_Set8001Delay("0"); // 测试步骤 TC_CANTest SOA Set8001Delay 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 6 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2856"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2856
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 6 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2856"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2856
}

testcase SYS_CDCU_Service_Err_1360()
{
  TestDescription("车窗未关_开启空调自清洁控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:100"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:100
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857
}

testcase SYS_CDCU_Service_Err_1361()
{
  TestDescription("车窗未关_开启空调自清洁控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:100"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:100
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857
}

testcase SYS_CDCU_Service_Err_1362()
{
  TestDescription("车窗未关_开启空调自清洁控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:100"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:100
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857
}

testcase SYS_CDCU_Service_Err_1363()
{
  TestDescription("车窗未关_开启空调自清洁控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:100"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:100
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857
}

testcase SYS_CDCU_Service_Err_1364()
{
  TestDescription("正在充电_开启空调自清洁控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 1"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 1
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 192 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 192 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2858"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2858
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 192 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 192 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2858"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2858
}

testcase SYS_CDCU_Service_Err_1365()
{
  TestDescription("正在充电_开启空调自清洁控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 2"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 192 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 192 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2858"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2858
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 192 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 192 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2858"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2858
}

testcase SYS_CDCU_Service_Err_1366()
{
  TestDescription("车门未关_开启空调自清洁控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
}

testcase SYS_CDCU_Service_Err_1367()
{
  TestDescription("车门未关_开启空调自清洁控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 1
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
}

testcase SYS_CDCU_Service_Err_1368()
{
  TestDescription("车门未关_开启空调自清洁控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
}

testcase SYS_CDCU_Service_Err_1369()
{
  TestDescription("车门未关_开启空调自清洁控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 1,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 1,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
}

testcase SYS_CDCU_Service_Err_1370()
{
  TestDescription("车门未关_开启空调自清洁控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 2"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 2
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
}

testcase SYS_CDCU_Service_Err_1371()
{
  TestDescription("开启前挡除霜除雾控制失败 Remote ON");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2843 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2843 traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2843 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2843 traceback20
}

testcase SYS_CDCU_Service_Err_1372()
{
  TestDescription("关闭前挡除霜除雾控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2844 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2844 traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2844 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2844 traceback20
}

testcase SYS_CDCU_Service_Err_1373()
{
  TestDescription("开启智能除味控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2862 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2862 traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2862 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2862 traceback20
}

testcase SYS_CDCU_Service_Err_1374()
{
  TestDescription("关闭智能除味控制失败 Remote ON");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2863 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2863 traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2863 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2863 traceback20
}

testcase SYS_CDCU_Service_Err_1375()
{
  TestDescription("开启空调控制失败 IG OFF");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("I_RDCU_NM.I_RDCU_NMRepeatMsgReqBit 1"); // 测试步骤 TC_CANTest SET I_RDCU_NM.I_RDCU_NMRepeatMsgReqBit 1 //网络唤醒维持帧
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
}

testcase SYS_CDCU_Service_Err_1376()
{
  TestDescription("开启空调控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
}

testcase SYS_CDCU_Service_Err_1377()
{
  TestDescription("开启空调控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
}

testcase SYS_CDCU_Service_Err_1378()
{
  TestDescription("开启空调控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
}

testcase SYS_CDCU_Service_Err_1379()
{
  TestDescription("开启空调控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
}

testcase SYS_CDCU_Service_Err_1380()
{
  TestDescription("开启空调控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
}

testcase SYS_CDCU_Service_Err_1381()
{
  TestDescription("关闭空调控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
}

testcase SYS_CDCU_Service_Err_1382()
{
  TestDescription("关闭空调控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
}

testcase SYS_CDCU_Service_Err_1383()
{
  TestDescription("关闭空调控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
}

testcase SYS_CDCU_Service_Err_1384()
{
  TestDescription("关闭空调控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
}

testcase SYS_CDCU_Service_Err_1385()
{
  TestDescription("关闭空调控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  gTC_CANTest_SOA_Set8001Delay("20"); // 预期结果 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E traceback20
}

testcase SYS_CDCU_Service_Err_1386()
{
  TestDescription("主驾温度调节控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F traceback20
}

testcase SYS_CDCU_Service_Err_1387()
{
  TestDescription("主驾温度调节控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  gTC_CANTest_SOA_Set8001Delay("20"); // 预期结果 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 预期结果 TC_CANTest SOA REQ Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 预期结果 TC_Sleep 15
}

testcase SYS_CDCU_Service_Err_1388()
{
  TestDescription("开启极速升温控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2847 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2847 traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2847 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2847 traceback20
}

testcase SYS_CDCU_Service_Err_1389()
{
  TestDescription("关闭极速升温控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2848 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2848 traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2848 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2848 traceback20
}

testcase SYS_CDCU_Service_Err_1390()
{
  TestDescription("开启极速降温控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2845 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2845 traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2845 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2845 traceback20
}

testcase SYS_CDCU_Service_Err_1391()
{
  TestDescription("关闭极速降温控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  gTC_CANTest_SOA_Set8001Delay("20"); // 预期结果 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 预期结果 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //OFF
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 预期结果 TC_Sleep 15
}

testcase SYS_CDCU_Service_Err_1392()
{
  TestDescription("开启高温抑菌控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284E traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284E traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284E traceback20
}

testcase SYS_CDCU_Service_Err_1393()
{
  TestDescription("关闭高温抑菌控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284D traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284D traceback20
}

testcase SYS_CDCU_Service_Err_1394()
{
  TestDescription("电量较低_开启高温抑菌控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 100,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 100,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_Set8001Delay("0"); // 测试步骤 TC_CANTest SOA Set8001Delay 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 6 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284B"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284B
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 6 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284B"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284B
}

testcase SYS_CDCU_Service_Err_1395()
{
  TestDescription("车窗未关_开启高温抑菌控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:100"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:100
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A
}

testcase SYS_CDCU_Service_Err_1396()
{
  TestDescription("车窗未关_开启高温抑菌控制失败 IG OFF");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:100"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:100
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A
}

testcase SYS_CDCU_Service_Err_1397()
{
  TestDescription("车窗未关_开启高温抑菌控制失败 IG OFF");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:100"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:100
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A
}

testcase SYS_CDCU_Service_Err_1398()
{
  TestDescription("车窗未关_开启高温抑菌控制失败 IG OFF");
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:100"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:100
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284A
}

testcase SYS_CDCU_Service_Err_1399()
{
  TestDescription("正在慢充_开启高温抑菌控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 2"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 192 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 192 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284C"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284C
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 192 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 192 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284C"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284C
}

testcase SYS_CDCU_Service_Err_1400()
{
  TestDescription("正在慢充_开启高温抑菌控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 1"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 1
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 192 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 192 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284C"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284C
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 192 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 192 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284C"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284C
}

testcase SYS_CDCU_Service_Err_1401()
{
  TestDescription("车门未关_开启高温抑菌控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
}

testcase SYS_CDCU_Service_Err_1402()
{
  TestDescription("车门未关_开启高温抑菌控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 1
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
}

testcase SYS_CDCU_Service_Err_1403()
{
  TestDescription("车门未关_开启高温抑菌控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
}

testcase SYS_CDCU_Service_Err_1404()
{
  TestDescription("车门未关_开启高温抑菌控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 1,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 1,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
}

testcase SYS_CDCU_Service_Err_1405()
{
  TestDescription("车门未关_开启高温抑菌控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 2"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 2
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284F
}

testcase SYS_CDCU_Service_Err_1406()
{
  TestDescription("开启空调自清洁控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A traceback20
}

testcase SYS_CDCU_Service_Err_1407()
{
  TestDescription("关闭空调自清洁控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A traceback20
}

testcase SYS_CDCU_Service_Err_1408()
{
  TestDescription("电量较低_开启空调自清洁控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 100,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 100,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  gTC_CANTest_SOA_Set8001Delay("0"); // 测试步骤 TC_CANTest SOA Set8001Delay 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 6 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2856"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2856
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 6 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2856"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2856
}

testcase SYS_CDCU_Service_Err_1409()
{
  TestDescription("车窗未关_开启空调自清洁控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:100"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:100
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  gTC_CANTest_SOA_Set8001Delay("0"); // 测试步骤 TC_CANTest SOA Set8001Delay 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857
}

testcase SYS_CDCU_Service_Err_1410()
{
  TestDescription("车窗未关_开启空调自清洁控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:100"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:100
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857
}

testcase SYS_CDCU_Service_Err_1411()
{
  TestDescription("车窗未关_开启空调自清洁控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:100"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:100
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857
}

testcase SYS_CDCU_Service_Err_1412()
{
  TestDescription("车窗未关_开启空调自清洁控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:100"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:100
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 193 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 193 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2857
}

testcase SYS_CDCU_Service_Err_1413()
{
  TestDescription("正在充电_开启空调自清洁控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 1"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 1
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 192 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 192 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2858"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2858
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 192 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 192 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2858"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2858
}

testcase SYS_CDCU_Service_Err_1414()
{
  TestDescription("正在充电_开启空调自清洁控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 2"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 2
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 192 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 192 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2858"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2858
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 192 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 192 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2858"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2858
}

testcase SYS_CDCU_Service_Err_1415()
{
  TestDescription("车门未关_开启空调自清洁控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 1,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
}

testcase SYS_CDCU_Service_Err_1416()
{
  TestDescription("车门未关_开启空调自清洁控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 1
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
}

testcase SYS_CDCU_Service_Err_1417()
{
  TestDescription("车门未关_开启空调自清洁控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 1,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
}

testcase SYS_CDCU_Service_Err_1418()
{
  TestDescription("车门未关_开启空调自清洁控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 1,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 1,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
}

testcase SYS_CDCU_Service_Err_1419()
{
  TestDescription("车门未关_开启空调自清洁控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 2"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 2
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:0
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:0
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:0"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 15 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 15 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2859
}

testcase SYS_CDCU_Service_Err_1420()
{
  TestDescription("开启前挡除霜除雾控制失败 IG OFF");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2843 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2843 traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2843 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2843 traceback20
}

testcase SYS_CDCU_Service_Err_1421()
{
  TestDescription("关闭前挡除霜除雾控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2844 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2844 traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2844 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2844 traceback20
}

testcase SYS_CDCU_Service_Err_1422()
{
  TestDescription("开启智能除味控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2862 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2862 traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2862 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2862 traceback20
}

testcase SYS_CDCU_Service_Err_1423()
{
  TestDescription("关闭智能除味控制失败 IG OFF");
  gTC_CANTest_SOA_Set8001Delay("20"); // 测试步骤 TC_CANTest SOA Set8001Delay 20
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2863 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2863 traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2863 traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2863 traceback20
}

testcase SYS_CDCU_qingqiuchaoshi_1424()
{
  TestDescription("开启空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1424");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  gTC_CANTest_SOA_Set8001Delay("0"); // 测试步骤 TC_CANTest SOA Set8001Delay 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1425()
{
  TestDescription("开启空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1425");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1426()
{
  TestDescription("开启空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1426");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1427()
{
  TestDescription("开启空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1427");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1428()
{
  TestDescription("开启空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1428");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1429()
{
  TestDescription("开启空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1429");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1430()
{
  TestDescription("关闭空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1430");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1431()
{
  TestDescription("关闭空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1431");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1432()
{
  TestDescription("关闭空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1432");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1433()
{
  TestDescription("关闭空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1433");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1434()
{
  TestDescription("关闭空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1434");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1435()
{
  TestDescription("主驾温度调节控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1435");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1436()
{
  TestDescription("主驾温度调节控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1436");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetDrvTempRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetDrvTempRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1437()
{
  TestDescription("开启极速升温控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1437");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1438()
{
  TestDescription("关闭极速升温控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1438");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1439()
{
  TestDescription("开启极速降温控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1439");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1440()
{
  TestDescription("关闭极速降温控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1440");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1441()
{
  TestDescription("开启高温抑菌控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1441");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&ReqTimeOut:20&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&ReqTimeOut:20&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1442()
{
  TestDescription("关闭高温抑菌控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1442");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&ReqTimeOut:20&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&ReqTimeOut:20&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1443()
{
  TestDescription("开启空调自清洁控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1443");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&ReqTimeOut:20&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&ReqTimeOut:20&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1444()
{
  TestDescription("关闭空调自清洁控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1444");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:1&ReqTimeOut:20&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:1&ReqTimeOut:20&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1445()
{
  TestDescription("开启前挡除霜除雾控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1445");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1446()
{
  TestDescription("关闭前挡除霜除雾控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1446");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1447()
{
  TestDescription("开启智能除味控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1447");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1448()
{
  TestDescription("关闭智能除味控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1448");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1449()
{
  TestDescription("开启空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1449");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("I_RDCU_NM.I_RDCU_NMRepeatMsgReqBit 1"); // 测试步骤 TC_CANTest SET I_RDCU_NM.I_RDCU_NMRepeatMsgReqBit 1 //网络唤醒维持帧
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1450()
{
  TestDescription("开启空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1450");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1451()
{
  TestDescription("开启空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1451");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1452()
{
  TestDescription("开启空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1452");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1453()
{
  TestDescription("开启空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1453");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1454()
{
  TestDescription("开启空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1454");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1455()
{
  TestDescription("关闭空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1455");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1455_1()
{
  TestDescription("关闭空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-qingqiuchaoshi-1455");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1456()
{
  TestDescription("关闭空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1456");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1457()
{
  TestDescription("关闭空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1457");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1458()
{
  TestDescription("关闭空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1458");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1459()
{
  TestDescription("关闭空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1459");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1460()
{
  TestDescription("主驾温度调节控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1460");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1461()
{
  TestDescription("主驾温度调节控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1461");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetDrvTempRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetDrvTempRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1462()
{
  TestDescription("开启极速升温控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1462");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1463()
{
  TestDescription("关闭极速升温控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1463");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1464()
{
  TestDescription("开启极速降温控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1464");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1465()
{
  TestDescription("关闭极速降温控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1465");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1466()
{
  TestDescription("开启高温抑菌控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1466");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&ReqTimeOut:20&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&ReqTimeOut:20&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1467()
{
  TestDescription("关闭高温抑菌控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1467");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&ReqTimeOut:20&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&ReqTimeOut:20&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1468()
{
  TestDescription("开启空调自清洁控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1468");
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&ReqTimeOut:20&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&ReqTimeOut:20&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1469()
{
  TestDescription("关闭空调自清洁控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1469");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:1&ReqTimeOut:20&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:1&ReqTimeOut:20&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1470()
{
  TestDescription("开启前挡除霜除雾控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1470");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1471()
{
  TestDescription("关闭前挡除霜除雾控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1471");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1472()
{
  TestDescription("开启智能除味控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1472");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_qingqiuchaoshi_1473()
{
  TestDescription("关闭智能除味控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-请求超时-1473");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&ReqTimeOut:20&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x01A4
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1474()
{
  TestDescription("开启空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1474");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  gTC_CANTest_SOA_SetSever("AcSysSt_ErrStruct.OpeNRC:1"); // 测试步骤 TC_CANTest SOA SetServer AcSysSt_ErrStruct.OpeNRC:1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D traceback20
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1475()
{
  TestDescription("开启空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1475");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1476()
{
  TestDescription("开启空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1476");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1477()
{
  TestDescription("开启空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1477");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1478()
{
  TestDescription("开启空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1478");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1479()
{
  TestDescription("开启空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1479");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1480()
{
  TestDescription("关闭空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1480");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1481()
{
  TestDescription("关闭空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1481");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1482()
{
  TestDescription("关闭空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1482");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1483()
{
  TestDescription("关闭空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1483");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1484()
{
  TestDescription("关闭空调控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1484");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1485()
{
  TestDescription("主驾温度调节控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1485");
  gTC_CANTest_SOA_SetSever("AcTempCtrl_ErrStruct.OpeNRC:1"); // 测试步骤 TC_CANTest SOA SetServer AcTempCtrl_ErrStruct.OpeNRC:1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1486()
{
  TestDescription("主驾温度调节控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1486");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetDrvTempRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetDrvTempRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1487()
{
  TestDescription("开启极速升温控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1487");
  gTC_CANTest_SOA_SetSever("AcBlwCtrl_ErrStruct.OpeNRC:1"); // 测试步骤 TC_CANTest SOA SetServer AcBlwCtrl_ErrStruct.OpeNRC:1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("2"); // 测试步骤 TC_Sleep 2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2847"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2847
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2847"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2847
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1488()
{
  TestDescription("关闭极速升温控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1488");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2848"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2848
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2848"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2848
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1489()
{
  TestDescription("开启极速降温控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1489");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2845"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2845
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2845"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2845
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1490()
{
  TestDescription("关闭极速降温控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1490");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2846"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2846
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2846"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2846
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1491()
{
  TestDescription("开启高温抑菌控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1491");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284E
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284E
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1492()
{
  TestDescription("关闭高温抑菌控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1492");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284D
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284D
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1493()
{
  TestDescription("开启空调自清洁控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1493");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1494()
{
  TestDescription("关闭空调自清洁控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1494");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1495()
{
  TestDescription("开启前挡除霜除雾控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1495");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2843"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2843
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2843"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2843
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1496()
{
  TestDescription("关闭前挡除霜除雾控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1496");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2844"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2844
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2844"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2844
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1497()
{
  TestDescription("开启智能除味控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1497");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2862"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2862
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2862"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2862
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1498()
{
  TestDescription("关闭智能除味控制失败 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1498");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2863"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2863
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2863"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2863
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1499()
{
  TestDescription("开启空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1499");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("I_RDCU_NM.I_RDCU_NMRepeatMsgReqBit 1"); // 测试步骤 TC_CANTest SET I_RDCU_NM.I_RDCU_NMRepeatMsgReqBit 1 //网络唤醒维持帧
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1500()
{
  TestDescription("开启空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1500");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1501()
{
  TestDescription("开启空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1501");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1502()
{
  TestDescription("开启空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1502");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1503()
{
  TestDescription("开启空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1503");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1504()
{
  TestDescription("开启空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1504");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283D
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1505()
{
  TestDescription("关闭空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1505");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1506()
{
  TestDescription("关闭空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1506");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrACStruct.Veh_TurnOnOffRrAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1507()
{
  TestDescription("关闭空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1507");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACStruct.Veh_TurnOnOffAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1508()
{
  TestDescription("关闭空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1508");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrAutoACStruct.Veh_TurnOnOffFrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffFrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffFrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1509()
{
  TestDescription("关闭空调控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1509");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffRrAutoACStruct.Veh_TurnOnOffRrAutoAC:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffRrAutoACRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffRrAutoACRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283E
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1510()
{
  TestDescription("主驾温度调节控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1510");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_DriverTempUpRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_DriverTempUpRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_DriverTempUpRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1511()
{
  TestDescription("主驾温度调节控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1511");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetDrvTempRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetDrvTempRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetDrvTempRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x283F
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1512()
{
  TestDescription("开启极速升温控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1512");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2847"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2847
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2847"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2847
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1513()
{
  TestDescription("关闭极速升温控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1513");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2848"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2848
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxHeatingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2848"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2848
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1514()
{
  TestDescription("开启极速降温控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1514");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2845"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2845
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2845"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2845
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1515()
{
  TestDescription("关闭极速降温控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1515");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2846"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2846
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffMaxCoolingRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2846"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2846
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1516()
{
  TestDescription("开启高温抑菌控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1516");
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284E
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284E"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284E
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1517()
{
  TestDescription("关闭高温抑菌控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1517");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284D
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffSterilizationRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffSterilizationRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284D"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x284D
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1518()
{
  TestDescription("开启空调自清洁控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1518");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1519()
{
  TestDescription("关闭空调自清洁控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1519");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffACSelfCleanRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x285A
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1520()
{
  TestDescription("开启前挡除霜除雾控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1520");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2843"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2843
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2843"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2843
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1521()
{
  TestDescription("关闭前挡除霜除雾控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1521");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2844"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2844
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_TurnOnOffDefrostRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_TurnOnOffDefrostRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2844"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2844
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1522()
{
  TestDescription("开启智能除味控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1522");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2862"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2862
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2862"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2862
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1523()
{
  TestDescription("关闭智能除味控制失败 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1523");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2863"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2863
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_SetOnOffDeodorizeRespStruct.RespCode 0"); // 预期结果 TC_CANTest SOA check Veh_SetOnOffDeodorizeRespStruct.RespCode 0
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2863"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x2863
}

testcase SYS_CDCU_yuanzifuwufanhuicuowu_1524()
{
  TestDescription("重置条件 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-原子服务返回错误-1524");
  gTC_CANTest_SOA_SetSever("LeftSideWindowService_ErrStruct.OpeNRC:0"); // 测试步骤 TC_CANTest SOA SetServer LeftSideWindowService_ErrStruct.OpeNRC:0
  gTC_CANTest_SOA_SetSever("RightSideWindowService_ErrStruct.OpeNRC:0"); // 测试步骤 TC_CANTest SOA SetServer RightSideWindowService_ErrStruct.OpeNRC:0
  gTC_CANTest_SOA_SetSever("SshdService_ErrStruct.OpeNRC:0"); // 测试步骤 TC_CANTest SOA SetServer SshdService_ErrStruct.OpeNRC:0
  gTC_CANTest_SOA_SetSever("AcSysSt_ErrStruct.OpeNRC:0"); // 测试步骤 TC_CANTest SOA SetServer AcSysSt_ErrStruct.OpeNRC:0
  gTC_CANTest_SOA_SetSever("AcTempCtrl_ErrStruct.OpeNRC:0"); // 测试步骤 TC_CANTest SOA SetServer AcTempCtrl_ErrStruct.OpeNRC:0
  gTC_CANTest_SOA_SetSever("AcBlwCtrl_ErrStruct.OpeNRC:0"); // 测试步骤 TC_CANTest SOA SetServer AcBlwCtrl_ErrStruct.OpeNRC:0
  gTC_CANTest_SOA_SetSever("FrontMirrorHeatService_ErrStruct.OpeNRC:0"); // 测试步骤 TC_CANTest SOA SetServer FrontMirrorHeatService_ErrStruct.OpeNRC:0
  gTC_CANTest_SOA_SetSever("RearMirrorHeatService_ErrStruct.OpeNRC:0"); // 测试步骤 TC_CANTest SOA SetServer RearMirrorHeatService_ErrStruct.OpeNRC:0
}

testcase SYS_CDCU_cheliangshangdianshibai_1525()
{
  TestDescription("远程控制开启空调 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1525");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 2"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 2
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 0"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 0//下高压
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangshangdianshibai_1526()
{
  TestDescription("远程控制主驾温度调节 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1526");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangshangdianshibai_1527()
{
  TestDescription("远程控制主驾温度调节 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1527");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangshangdianshibai_1528()
{
  TestDescription("远程控制开启空调极速升温 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1528");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangshangdianshibai_1529()
{
  TestDescription("远程控制开启空调极速降温 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1529");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangshangdianshibai_1530()
{
  TestDescription("远程控制开启空调高温抑菌 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1530");
  g_CAN_Bus_Swc_Set("I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0"); // 测试步骤 TC_CANTest SET I_LDCU_SysStDisp1.I_LDCU_dstBatDisp 150,I_LDCU_ChrgConnSt_Disp 0
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_DriverDoorAjarSt 0,I_LDCU_RLDoorAjarSt 0
  g_CAN_Bus_Swc_Set("I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0"); // 测试步骤 TC_CANTest SET I_RDCU_BodySysSt1.I_RDCU_PsngrDoorAjarSt 0,I_RDCU_RRDoorAjarSt 0,I_RDCU_PLGSts 0
  gTC_CANTest_SOA_SetSever("FLWindowSt2Struct.FLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FLWindowSt2Struct.FLWinPosStFB:2
  gTC_CANTest_SOA_SetSever("FRWindowSt2Struct.FRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer FRWindowSt2Struct.FRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RRWindowSt2Struct.RRWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RRWindowSt2Struct.RRWinPosStFB:2
  gTC_CANTest_SOA_SetSever("RLWindowSt2Struct.RLWinPosStFB:2"); // 测试步骤 TC_CANTest SOA SetServer RLWindowSt2Struct.RLWinPosStFB:2
  g_CAN_Bus_Swc_Set("I_LDCU_TgateSysSts.I_TgatePosSts 1"); // 测试步骤 TC_CANTest SET I_LDCU_TgateSysSts.I_TgatePosSts 1
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangshangdianshibai_1531()
{
  TestDescription("远程控制开启空调自清洁 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1531");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangshangdianshibai_1532()
{
  TestDescription("远程控制开启前档除霜除雾 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1532");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangshangdianshibai_1533()
{
  TestDescription("远程控制开启智能除味 Remote ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1533");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangshangdianshibai_1534()
{
  TestDescription("远程控制开启空调 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1534");
  g_EM_Equipment_Swc_TC_IG("OFF"); // 测试步骤 TC_IG OFF
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 0"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 0
  g_CAN_Bus_Swc_Set("I_RDCU_NM.I_RDCU_NMRepeatMsgReqBit 1"); // 测试步骤 TC_CANTest SET I_RDCU_NM.I_RDCU_NMRepeatMsgReqBit 1 //网络唤醒维持帧
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangshangdianshibai_1535()
{
  TestDescription("远程控制主驾温度调节 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1535");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangshangdianshibai_1536()
{
  TestDescription("远程控制主驾温度调节 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1536");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangshangdianshibai_1537()
{
  TestDescription("远程控制开启空调极速升温 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1537");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangshangdianshibai_1538()
{
  TestDescription("远程控制开启空调极速降温 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1538");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangshangdianshibai_1539()
{
  TestDescription("远程控制开启空调高温抑菌 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1539");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangshangdianshibai_1540()
{
  TestDescription("远程控制开启空调自清洁 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1540");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangshangdianshibai_1541()
{
  TestDescription("远程控制开启前档除霜除雾 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1541");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangshangdianshibai_1542()
{
  TestDescription("远程控制开启智能除味 IG OFF");
  teststep("warning","原始用例id为SYS-CDCU-车辆上电失败-1542");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_Equipment_Swc_TC_4G_Time_Delay_Second("15"); // 测试步骤 TC_Sleep 15
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeNRC 4 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeNRC 4 traceback10
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x6 traceback10
}

testcase SYS_CDCU_cheliangyiqidong_1543()
{
  TestDescription("远程控制开启空调 IG ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆已启动-1543");
  g_EM_Equipment_Swc_TC_IG("ON"); // 测试步骤 TC_IG ON
  g_CAN_Bus_Swc_Set("I_LDCU_BodySysSt1.I_LDCU_PowerMode 1"); // 测试步骤 TC_CANTest SET I_LDCU_BodySysSt1.I_LDCU_PowerMode 1
  g_CAN_Bus_Swc_Set("C_LDCU_SysSt.C_LDCU_EVSysReadySt 2"); // 测试步骤 TC_CANTest SET C_LDCU_SysSt.C_LDCU_EVSysReadySt 2//上高压
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffFrACStruct.Veh_TurnOnOffFrAC:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
}

testcase SYS_CDCU_cheliangyiqidong_1544()
{
  TestDescription("远程控制主驾温度调节 IG ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆已启动-1544");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
  g_EM_SOAClient_Swc_SOA_REQ("Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_DriverTempUpStruct.Veh_DriverTempUp:1&MemoryReq:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //0.5步进
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
}

testcase SYS_CDCU_cheliangyiqidong_1545()
{
  TestDescription("远程控制主驾温度调节 IG ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆已启动-1545");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetDrvTempStruct.Veh_SetDrvTemp:25&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
}

testcase SYS_CDCU_cheliangyiqidong_1546()
{
  TestDescription("远程控制开启空调极速升温 IG ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆已启动-1546");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
}

testcase SYS_CDCU_cheliangyiqidong_1547()
{
  TestDescription("远程控制关闭空调极速升温 IG ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆已启动-1547");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxHeatingStruct.Veh_TurnOnOffMaxHeating:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
}

testcase SYS_CDCU_cheliangyiqidong_1548()
{
  TestDescription("远程控制开启空调极速降温 IG ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆已启动-1548");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
}

testcase SYS_CDCU_cheliangyiqidong_1549()
{
  TestDescription("远程控制关闭空调极速降温 IG ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆已启动-1549");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffMaxCoolingStruct.Veh_TurnOnOffMaxCooling:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1 //OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
}

testcase SYS_CDCU_cheliangyiqidong_1550()
{
  TestDescription("远程控制开启空调高温抑菌 IG ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆已启动-1550");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
}

testcase SYS_CDCU_cheliangyiqidong_1551()
{
  TestDescription("远程控制关闭空调高温抑菌 IG ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆已启动-1551");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffSterilizationStruct.Veh_TurnOnOffSterilization:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
}

testcase SYS_CDCU_cheliangyiqidong_1552()
{
  TestDescription("远程控制开启空调自清洁 IG ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆已启动-1552");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:2&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
}

testcase SYS_CDCU_cheliangyiqidong_1553()
{
  TestDescription("远程控制关闭空调自清洁 IG ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆已启动-1553");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffACSelfCleanStruct.Veh_TurnOnOffACSelfClean:1&UserID:0x01010001&ServiceExecuteFeedbackFlag:2//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
}

testcase SYS_CDCU_cheliangyiqidong_1554()
{
  TestDescription("远程控制开启前档除霜除雾 IG ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆已启动-1554");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
}

testcase SYS_CDCU_cheliangyiqidong_1555()
{
  TestDescription("远程控制关闭前档除霜除雾 IG ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆已启动-1555");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
  g_EM_SOAClient_Swc_SOA_REQ("Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_TurnOnOffDefrostStruct.Veh_TurnOnOffDefrost:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
}

testcase SYS_CDCU_cheliangyiqidong_1556()
{
  TestDescription("远程控制开启智能除味 IG ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆已启动-1556");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:2&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//ON
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
}

testcase SYS_CDCU_cheliangyiqidong_1557()
{
  TestDescription("远程控制关闭智能除味 IG ON");
  teststep("warning","原始用例id为SYS-CDCU-车辆已启动-1557");
  g_EM_SOAClient_Swc_SOA_CHECK_Prepare("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
  g_EM_SOAClient_Swc_SOA_REQ("Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1"); // 测试步骤 TC_CANTest SOA REQ Veh_SetOnOffDeodorizeStruct.Veh_SetOnOffDeodorize:1&ServiceExecuteFeedbackFlag:2&UserID:0x01010001&Time:1//OFF
  g_EM_SOAClient_Swc_SOA_CHECK("Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9"); // 预期结果 TC_CANTest SOA check Veh_HVACService_ErrStruct.OpeErrInfo[0-1]:0x9
}
